m16cl in swec
MN7648   Z15      #3245    0      0      MN1      W=    1.80u L=1.0u
MN7647   Z13      #3244    0      0      MN1      W=    1.80u L=1.0u
MN7646   Z11      #3243    0      0      MN1      W=    1.80u L=1.0u
MN7645   Z9       #3242    0      0      MN1      W=    1.80u L=1.0u
MN7644   Z7       #3241    0      0      MN1      W=    1.80u L=1.0u
MN7643   Z5       #3240    0      0      MN1      W=    1.80u L=1.0u
MN7642   Z3       #3239    0      0      MN1      W=    1.80u L=1.0u
MN7641   Z1       #3238    0      0      MN1      W=    1.80u L=1.0u
MN7640   Z14      #3220    0      0      MN1      W=    1.80u L=1.0u
MN7639   Z12      #3219    0      0      MN1      W=    1.80u L=1.0u
MN7638   Z10      #3218    0      0      MN1      W=    1.80u L=1.0u
MN7637   Z8       #3217    0      0      MN1      W=    1.80u L=1.0u
MN7636   Z6       #3216    0      0      MN1      W=    1.80u L=1.0u
MN7635   Z4       #3215    0      0      MN1      W=    1.80u L=1.0u
MN7634   Z2       #3214    0      0      MN1      W=    1.80u L=1.0u
MN7633   Z0       #3230    0      0      MN1      W=    1.80u L=1.0u
MP7632   Z16      #2866    1      1      MP1      W=    1.80u L=1.0u
MP7631   #3317    #3245    1      1      MP1      W=    1.80u L=1.0u
MP7630   #3332    #3220    1      1      MP1      W=    1.80u L=1.0u
MP7629   #3331    #3244    1      1      MP1      W=    1.80u L=1.0u
MP7628   #3330    #3219    1      1      MP1      W=    1.80u L=1.0u
MP7627   #3329    #3243    1      1      MP1      W=    1.80u L=1.0u
MP7626   #3328    #3218    1      1      MP1      W=    1.80u L=1.0u
MP7625   #3327    #3242    1      1      MP1      W=    1.80u L=1.0u
MP7624   #3326    #3217    1      1      MP1      W=    1.80u L=1.0u
MP7623   #3325    #3241    1      1      MP1      W=    1.80u L=1.0u
MP7622   #3324    #3216    1      1      MP1      W=    1.80u L=1.0u
MP7621   #3323    #3240    1      1      MP1      W=    1.80u L=1.0u
MP7620   #3322    #3215    1      1      MP1      W=    1.80u L=1.0u
MP7619   #3321    #3239    1      1      MP1      W=    1.80u L=1.0u
MP7618   #3320    #3214    1      1      MP1      W=    1.80u L=1.0u
MP7617   #3319    #3238    1      1      MP1      W=    1.80u L=1.0u
MP7616   #3318    #3230    1      1      MP1      W=    1.80u L=1.0u
MN7615   #3316    #2866    0      0      MN1      W=    1.80u L=1.0u
MN7614   0      #3297    Z14      0      MN1      W=    1.80u L=1.0u
MN7613   0      #3296    Z12      0      MN1      W=    1.80u L=1.0u
MN7612   0      #3295    Z10      0      MN1      W=    1.80u L=1.0u
MN7611   0      #3294    Z8       0      MN1      W=    1.80u L=1.0u
MN7610   0      #3293    Z6       0      MN1      W=    1.80u L=1.0u
MN7609   0      #3292    Z4       0      MN1      W=    1.80u L=1.0u
MN7608   0      #3291    Z2       0      MN1      W=    1.80u L=1.0u
MN7607   0      #3298    Z0       0      MN1      W=    1.80u L=1.0u
MP7606   Z14      #3297    #3332    1      MP1      W=    1.80u L=1.0u
MP7605   Z13      #3289    #3331    1      MP1      W=    1.80u L=1.0u
MP7604   Z12      #3296    #3330    1      MP1      W=    1.80u L=1.0u
MP7603   Z11      #3288    #3329    1      MP1      W=    1.80u L=1.0u
MP7602   Z10      #3295    #3328    1      MP1      W=    1.80u L=1.0u
MP7601   Z9       #3287    #3327    1      MP1      W=    1.80u L=1.0u
MP7600   Z8       #3294    #3326    1      MP1      W=    1.80u L=1.0u
MP7599   Z7       #3286    #3325    1      MP1      W=    1.80u L=1.0u
MP7598   Z6       #3293    #3324    1      MP1      W=    1.80u L=1.0u
MP7597   Z5       #3285    #3323    1      MP1      W=    1.80u L=1.0u
MP7596   Z4       #3292    #3322    1      MP1      W=    1.80u L=1.0u
MP7595   Z3       #3284    #3321    1      MP1      W=    1.80u L=1.0u
MP7594   Z2       #3291    #3320    1      MP1      W=    1.80u L=1.0u
MP7593   Z1       #3283    #3319    1      MP1      W=    1.80u L=1.0u
MP7592   Z0       #3298    #3318    1      MP1      W=    1.80u L=1.0u
MP7591   Z15      #3290    #3317    1      MP1      W=    1.80u L=1.0u
MN7590   Z16      #3282    #3316    0      MN1      W=    1.80u L=1.0u
MN7589   0      #3290    Z15      0      MN1      W=    1.80u L=1.0u
MN7588   0      #3289    Z13      0      MN1      W=    1.80u L=1.0u
MN7587   0      #3288    Z11      0      MN1      W=    1.80u L=1.0u
MN7586   0      #3287    Z9       0      MN1      W=    1.80u L=1.0u
MN7585   0      #3286    Z7       0      MN1      W=    1.80u L=1.0u
MN7584   0      #3285    Z5       0      MN1      W=    1.80u L=1.0u
MN7583   0      #3284    Z3       0      MN1      W=    1.80u L=1.0u
MN7582   0      #3283    Z1       0      MN1      W=    1.80u L=1.0u
MP7581   1      #3282    Z16      1      MP1      W=    1.80u L=1.0u
MN7580   0      #3213    #3298    0      MN1      W=    1.80u L=1.0u
MP7579   1      #3213    #3298    1      MP1      W=    1.80u L=1.0u
MN7578   0      #3237    #3297    0      MN1      W=    1.80u L=1.0u
MN7577   0      #3236    #3296    0      MN1      W=    1.80u L=1.0u
MN7576   0      #3235    #3295    0      MN1      W=    1.80u L=1.0u
MN7575   0      #3234    #3294    0      MN1      W=    1.80u L=1.0u
MN7574   0      #3233    #3293    0      MN1      W=    1.80u L=1.0u
MN7573   0      #3232    #3292    0      MN1      W=    1.80u L=1.0u
MN7572   0      #3231    #3291    0      MN1      W=    1.80u L=1.0u
MP7571   1      #3237    #3297    1      MP1      W=    1.80u L=1.0u
MP7570   1      #3236    #3296    1      MP1      W=    1.80u L=1.0u
MP7569   1      #3235    #3295    1      MP1      W=    1.80u L=1.0u
MP7568   1      #3234    #3294    1      MP1      W=    1.80u L=1.0u
MP7567   1      #3233    #3293    1      MP1      W=    1.80u L=1.0u
MP7566   1      #3232    #3292    1      MP1      W=    1.80u L=1.0u
MP7565   1      #3231    #3291    1      MP1      W=    1.80u L=1.0u
MP7564   1      #3228    #3290    1      MP1      W=    1.80u L=1.0u
MN7563   0      #3228    #3290    0      MN1      W=    1.80u L=1.0u
MP7562   1      #3227    #3289    1      MP1      W=    1.80u L=1.0u
MP7561   1      #3226    #3288    1      MP1      W=    1.80u L=1.0u
MP7560   1      #3225    #3287    1      MP1      W=    1.80u L=1.0u
MP7559   1      #3224    #3286    1      MP1      W=    1.80u L=1.0u
MP7558   1      #3223    #3285    1      MP1      W=    1.80u L=1.0u
MP7557   1      #3222    #3284    1      MP1      W=    1.80u L=1.0u
MP7556   1      #3221    #3283    1      MP1      W=    1.80u L=1.0u
MN7555   0      #3227    #3289    0      MN1      W=    1.80u L=1.0u
MN7554   0      #3226    #3288    0      MN1      W=    1.80u L=1.0u
MN7553   0      #3225    #3287    0      MN1      W=    1.80u L=1.0u
MN7552   0      #3224    #3286    0      MN1      W=    1.80u L=1.0u
MN7551   0      #3223    #3285    0      MN1      W=    1.80u L=1.0u
MN7550   0      #3222    #3284    0      MN1      W=    1.80u L=1.0u
MN7549   0      #3221    #3283    0      MN1      W=    1.80u L=1.0u
MN7548   0      #3229    #3282    0      MN1      W=    1.80u L=1.0u
MP7547   1      #3229    #3282    1      MP1      W=    1.80u L=1.0u
MP7546   #3213    #3126    1      1      MP1      W=    5.40u L=1.0u
MP7545   #3237    #3028    1      1      MP1      W=    5.40u L=1.0u
MP7544   #3236    #3027    1      1      MP1      W=    5.40u L=1.0u
MP7543   #3235    #3026    1      1      MP1      W=    5.40u L=1.0u
MP7542   #3234    #3025    1      1      MP1      W=    5.40u L=1.0u
MP7541   #3233    #3024    1      1      MP1      W=    5.40u L=1.0u
MP7540   #3232    #3023    1      1      MP1      W=    5.40u L=1.0u
MP7539   #3231    #3022    1      1      MP1      W=    5.40u L=1.0u
MN7538   #3245    #3036    0      0      MN1      W=    5.40u L=1.0u
MN7537   #3220    #3028    0      0      MN1      W=    5.40u L=1.0u
MP7536   #3227    #3035    1      1      MP1      W=    5.40u L=1.0u
MN7535   #3244    #3035    0      0      MN1      W=    5.40u L=1.0u
MN7534   #3219    #3027    0      0      MN1      W=    5.40u L=1.0u
MP7533   #3226    #3034    1      1      MP1      W=    5.40u L=1.0u
MN7532   #3243    #3034    0      0      MN1      W=    5.40u L=1.0u
MN7531   #3218    #3026    0      0      MN1      W=    5.40u L=1.0u
MP7530   #3225    #3033    1      1      MP1      W=    5.40u L=1.0u
MN7529   #3242    #3033    0      0      MN1      W=    5.40u L=1.0u
MN7528   #3217    #3025    0      0      MN1      W=    5.40u L=1.0u
MP7527   #3224    #3032    1      1      MP1      W=    5.40u L=1.0u
MN7526   #3241    #3032    0      0      MN1      W=    5.40u L=1.0u
MN7525   #3216    #3024    0      0      MN1      W=    5.40u L=1.0u
MP7524   #3223    #3031    1      1      MP1      W=    5.40u L=1.0u
MN7523   #3240    #3031    0      0      MN1      W=    5.40u L=1.0u
MN7522   #3215    #3023    0      0      MN1      W=    5.40u L=1.0u
MP7521   #3222    #3030    1      1      MP1      W=    5.40u L=1.0u
MN7520   #3239    #3030    0      0      MN1      W=    5.40u L=1.0u
MN7519   #3214    #3022    0      0      MN1      W=    5.40u L=1.0u
MP7518   #3221    #3124    1      1      MP1      W=    5.40u L=1.0u
MN7517   #3238    #3124    0      0      MN1      W=    5.40u L=1.0u
MN7516   #3230    #3126    0      0      MN1      W=    5.40u L=1.0u
MN7515   #3229    #3029    0      0      MN1      W=    5.40u L=1.0u
MP7514   #3228    #3036    1      1      MP1      W=    5.40u L=1.0u
MP7513   #2866    #3029    1      1      MP1      W=    5.40u L=1.0u
MP7512   1      #3125    #3213    1      MP1      W=    1.80u L=1.0u
MN7511   0      #3125    #3230    0      MN1      W=    5.40u L=1.0u
MN7510   0      #3227    #3220    0      MN1      W=    5.40u L=1.0u
MP7509   1      #3227    #3237    1      MP1      W=    1.80u L=1.0u
MP7508   1      #3219    #3227    1      MP1      W=    5.40u L=1.0u
MN7507   0      #3226    #3219    0      MN1      W=    5.40u L=1.0u
MP7506   1      #3226    #3236    1      MP1      W=    1.80u L=1.0u
MP7505   1      #3218    #3226    1      MP1      W=    5.40u L=1.0u
MN7504   0      #3225    #3218    0      MN1      W=    5.40u L=1.0u
MP7503   1      #3225    #3235    1      MP1      W=    1.80u L=1.0u
MP7502   1      #3217    #3225    1      MP1      W=    5.40u L=1.0u
MN7501   0      #3224    #3217    0      MN1      W=    5.40u L=1.0u
MP7500   1      #3224    #3234    1      MP1      W=    1.80u L=1.0u
MP7499   1      #3216    #3224    1      MP1      W=    5.40u L=1.0u
MN7498   0      #3223    #3216    0      MN1      W=    5.40u L=1.0u
MP7497   1      #3223    #3233    1      MP1      W=    1.80u L=1.0u
MP7496   1      #3215    #3223    1      MP1      W=    5.40u L=1.0u
MN7495   0      #3222    #3215    0      MN1      W=    5.40u L=1.0u
MP7494   1      #3222    #3232    1      MP1      W=    1.80u L=1.0u
MP7493   1      #3214    #3222    1      MP1      W=    5.40u L=1.0u
MN7492   0      #3221    #3214    0      MN1      W=    5.40u L=1.0u
MP7491   1      #3221    #3231    1      MP1      W=    1.80u L=1.0u
MP7490   1      #3230    #3221    1      MP1      W=    5.40u L=1.0u
MN7489   0      #3220    #3245    0      MN1      W=    1.80u L=1.0u
MN7488   0      #3219    #3244    0      MN1      W=    1.80u L=1.0u
MN7487   0      #3218    #3243    0      MN1      W=    1.80u L=1.0u
MN7486   0      #3217    #3242    0      MN1      W=    1.80u L=1.0u
MN7485   0      #3216    #3241    0      MN1      W=    1.80u L=1.0u
MN7484   0      #3215    #3240    0      MN1      W=    1.80u L=1.0u
MN7483   0      #3214    #3239    0      MN1      W=    1.80u L=1.0u
MN7482   0      #3230    #3238    0      MN1      W=    1.80u L=1.0u
MN7481   0      #3228    #3229    0      MN1      W=    1.80u L=1.0u
MP7480   1      #3220    #3228    1      MP1      W=    5.40u L=1.0u
MP7479   1      #3228    #2866    1      MP1      W=    5.40u L=1.0u
MP7478   #3265    #3126    1      1      MP1      W=   16.20u L=1.0u
MN7477   #3262    #3036    0      0      MN1      W=   16.20u L=1.0u
MP7476   #3253    #3028    1      1      MP1      W=   16.20u L=1.0u
MN7475   #3261    #3035    0      0      MN1      W=   16.20u L=1.0u
MP7474   #3252    #3027    1      1      MP1      W=   16.20u L=1.0u
MN7473   #3260    #3034    0      0      MN1      W=   16.20u L=1.0u
MP7472   #3251    #3026    1      1      MP1      W=   16.20u L=1.0u
MN7471   #3259    #3033    0      0      MN1      W=   16.20u L=1.0u
MP7470   #3250    #3025    1      1      MP1      W=   16.20u L=1.0u
MN7469   #3258    #3032    0      0      MN1      W=   16.20u L=1.0u
MP7468   #3249    #3024    1      1      MP1      W=   16.20u L=1.0u
MN7467   #3257    #3031    0      0      MN1      W=   16.20u L=1.0u
MP7466   #3248    #3023    1      1      MP1      W=   16.20u L=1.0u
MN7465   #3256    #3030    0      0      MN1      W=   16.20u L=1.0u
MP7464   #3247    #3022    1      1      MP1      W=   16.20u L=1.0u
MN7463   #3255    #3124    0      0      MN1      W=   16.20u L=1.0u
MN7462   #3254    #3029    0      0      MN1      W=   16.20u L=1.0u
MP7444   1      X0       #3038    1      MP1      W=   10.80u L=1.0u
MN7443   0      X0       #3038    0      MN1      W=    3.60u L=1.0u
MP7442   #3279    #3035    1      1      MP1      W=    5.40u L=1.0u
MP7441   #3278    #3034    1      1      MP1      W=    5.40u L=1.0u
MP7440   #3277    #3033    1      1      MP1      W=    5.40u L=1.0u
MP7439   #3276    #3032    1      1      MP1      W=    5.40u L=1.0u
MP7438   #3275    #3031    1      1      MP1      W=    5.40u L=1.0u
MP7437   #3274    #3030    1      1      MP1      W=    5.40u L=1.0u
MP7436   #3273    #3124    1      1      MP1      W=    5.40u L=1.0u
MP7435   #3280    #3036    1      1      MP1      W=    5.40u L=1.0u
MN7432   #3272    #3028    0      0      MN1      W=    5.40u L=1.0u
MN7430   #3271    #3027    0      0      MN1      W=    5.40u L=1.0u
MN7428   #3270    #3026    0      0      MN1      W=    5.40u L=1.0u
MN7426   #3269    #3025    0      0      MN1      W=    5.40u L=1.0u
MN7424   #3268    #3024    0      0      MN1      W=    5.40u L=1.0u
MN7422   #3267    #3023    0      0      MN1      W=    5.40u L=1.0u
MN7420   #3266    #3022    0      0      MN1      W=    5.40u L=1.0u
MN7418   #3264    #3126    0      0      MN1      W=    5.40u L=1.0u
MP7409   #3263    #3029    1      1      MP1      W=    5.40u L=1.0u
MP7408   #3106    X1       1      1      MP1      W=   10.80u L=1.0u
MN7407   #3246    X1       0      0      MN1      W=    3.60u L=1.0u
MP7406   #3245    #3220    #3280    1      MP1      W=    1.80u L=1.0u
MP7405   #3244    #3219    #3279    1      MP1      W=    1.80u L=1.0u
MP7404   #3243    #3218    #3278    1      MP1      W=    1.80u L=1.0u
MP7403   #3242    #3217    #3277    1      MP1      W=    1.80u L=1.0u
MP7402   #3241    #3216    #3276    1      MP1      W=    1.80u L=1.0u
MP7401   #3240    #3215    #3275    1      MP1      W=    1.80u L=1.0u
MP7400   #3239    #3214    #3274    1      MP1      W=    1.80u L=1.0u
MP7399   #3238    #3230    #3273    1      MP1      W=    1.80u L=1.0u
MN7398   #3237    #3227    #3272    0      MN1      W=    1.80u L=1.0u
MN7397   #3236    #3226    #3271    0      MN1      W=    1.80u L=1.0u
MN7396   #3235    #3225    #3270    0      MN1      W=    1.80u L=1.0u
MN7395   #3234    #3224    #3269    0      MN1      W=    1.80u L=1.0u
MN7394   #3233    #3223    #3268    0      MN1      W=    1.80u L=1.0u
MN7393   #3232    #3222    #3267    0      MN1      W=    1.80u L=1.0u
MN7392   #3231    #3221    #3266    0      MN1      W=    1.80u L=1.0u
MP7391   #3230    #3125    #3265    1      MP1      W=    5.40u L=1.0u
MN7390   #3213    #3125    #3264    0      MN1      W=    1.80u L=1.0u
MP7389   #3229    #3228    #3263    1      MP1      W=    1.80u L=1.0u
MN7388   #3228    #3220    #3262    0      MN1      W=    5.40u L=1.0u
MN7387   #3227    #3219    #3261    0      MN1      W=    5.40u L=1.0u
MN7386   #3226    #3218    #3260    0      MN1      W=    5.40u L=1.0u
MN7385   #3225    #3217    #3259    0      MN1      W=    5.40u L=1.0u
MN7384   #3224    #3216    #3258    0      MN1      W=    5.40u L=1.0u
MN7383   #3223    #3215    #3257    0      MN1      W=    5.40u L=1.0u
MN7382   #3222    #3214    #3256    0      MN1      W=    5.40u L=1.0u
MN7381   #3221    #3230    #3255    0      MN1      W=    5.40u L=1.0u
MN7380   #2866    #3228    #3254    0      MN1      W=    5.40u L=1.0u
MP7379   #3220    #3227    #3253    1      MP1      W=    5.40u L=1.0u
MP7378   #3219    #3226    #3252    1      MP1      W=    5.40u L=1.0u
MP7377   #3218    #3225    #3251    1      MP1      W=    5.40u L=1.0u
MP7376   #3217    #3224    #3250    1      MP1      W=    5.40u L=1.0u
MP7375   #3216    #3223    #3249    1      MP1      W=    5.40u L=1.0u
MP7374   #3215    #3222    #3248    1      MP1      W=    5.40u L=1.0u
MP7373   #3214    #3221    #3247    1      MP1      W=    5.40u L=1.0u
MN7372   #3106    #3038    #3246    0      MN1      W=    3.60u L=1.0u
MP7371   1      #3038    #3106    1      MP1      W=   10.80u L=1.0u
MN7370   0      #3072    #3143    0      MN1      W=    3.60u L=1.0u
MN7369   0      #3071    #3135    0      MN1      W=    3.60u L=1.0u
MN7368   0      #3087    #3142    0      MN1      W=    3.60u L=1.0u
MN7367   0      #3086    #3133    0      MN1      W=    3.60u L=1.0u
MN7366   0      #3085    #3141    0      MN1      W=    3.60u L=1.0u
MN7365   0      #3084    #3132    0      MN1      W=    3.60u L=1.0u
MN7364   0      #3083    #3140    0      MN1      W=    3.60u L=1.0u
MN7363   0      #3082    #3131    0      MN1      W=    3.60u L=1.0u
MN7362   0      #3081    #3139    0      MN1      W=    3.60u L=1.0u
MN7361   0      #3080    #3130    0      MN1      W=    3.60u L=1.0u
MN7360   0      #3079    #3138    0      MN1      W=    3.60u L=1.0u
MN7359   0      #3078    #3129    0      MN1      W=    3.60u L=1.0u
MN7358   0      #3077    #3137    0      MN1      W=    3.60u L=1.0u
MN7357   0      #3076    #3128    0      MN1      W=    3.60u L=1.0u
MN7356   0      #3075    #3136    0      MN1      W=    3.60u L=1.0u
MP7355   1      #3072    #3143    1      MP1      W=    3.60u L=1.0u
MP7354   1      #3071    #3135    1      MP1      W=    3.60u L=1.0u
MP7353   1      #3087    #3142    1      MP1      W=    3.60u L=1.0u
MP7352   1      #3086    #3133    1      MP1      W=    3.60u L=1.0u
MP7351   1      #3085    #3141    1      MP1      W=    3.60u L=1.0u
MP7350   1      #3084    #3132    1      MP1      W=    3.60u L=1.0u
MP7349   1      #3083    #3140    1      MP1      W=    3.60u L=1.0u
MP7348   1      #3082    #3131    1      MP1      W=    3.60u L=1.0u
MP7347   1      #3081    #3139    1      MP1      W=    3.60u L=1.0u
MP7346   1      #3080    #3130    1      MP1      W=    3.60u L=1.0u
MP7345   1      #3079    #3138    1      MP1      W=    3.60u L=1.0u
MP7344   1      #3078    #3129    1      MP1      W=    3.60u L=1.0u
MP7343   1      #3077    #3137    1      MP1      W=    3.60u L=1.0u
MP7342   1      #3076    #3128    1      MP1      W=    3.60u L=1.0u
MP7341   1      #3075    #3136    1      MP1      W=    3.60u L=1.0u
MP7340   1      #3074    #3127    1      MP1      W=    3.60u L=1.0u
MN7339   0      #3074    #3127    0      MN1      W=    3.60u L=1.0u
MP7338   1      #3088    #3134    1      MP1      W=    3.60u L=1.0u
MP7337   #3178    #3126    1      1      MP1      W=   21.60u L=1.0u
MN7336   0      #3088    #3134    0      MN1      W=    3.60u L=1.0u
MN7335   #3178    #3126    0      0      MN1      W=    7.20u L=1.0u
MP7332   #3212    #3143    1      1      MP1      W=    3.60u L=1.0u
MP7331   #3211    #3135    1      1      MP1      W=    3.60u L=1.0u
MP7330   #3210    #3087    1      1      MP1      W=    3.60u L=1.0u
MP7329   #3209    #3133    1      1      MP1      W=    3.60u L=1.0u
MP7328   #3208    #3085    1      1      MP1      W=    3.60u L=1.0u
MP7327   #3207    #3132    1      1      MP1      W=    3.60u L=1.0u
MP7326   #3206    #3083    1      1      MP1      W=    3.60u L=1.0u
MP7325   #3205    #3131    1      1      MP1      W=    3.60u L=1.0u
MP7324   #3204    #3081    1      1      MP1      W=    3.60u L=1.0u
MP7323   #3203    #3130    1      1      MP1      W=    3.60u L=1.0u
MP7322   #3202    #3079    1      1      MP1      W=    3.60u L=1.0u
MP7321   #3201    #3129    1      1      MP1      W=    3.60u L=1.0u
MP7320   #3200    #3077    1      1      MP1      W=    3.60u L=1.0u
MP7319   #3199    #3128    1      1      MP1      W=    3.60u L=1.0u
MP7318   #3198    #3075    1      1      MP1      W=    3.60u L=1.0u
MP7317   #3197    #3127    1      1      MP1      W=    3.60u L=1.0u
MP7316   #3196    #3088    1      1      MP1      W=    3.60u L=1.0u
MN7315   #3195    #3072    0      0      MN1      W=    3.60u L=1.0u
MN7314   #3194    #3071    0      0      MN1      W=    3.60u L=1.0u
MN7313   #3193    #3142    0      0      MN1      W=    3.60u L=1.0u
MN7312   #3192    #3086    0      0      MN1      W=    3.60u L=1.0u
MN7311   #3191    #3141    0      0      MN1      W=    3.60u L=1.0u
MN7310   #3190    #3084    0      0      MN1      W=    3.60u L=1.0u
MN7309   #3189    #3140    0      0      MN1      W=    3.60u L=1.0u
MN7308   #3188    #3082    0      0      MN1      W=    3.60u L=1.0u
MN7307   #3187    #3139    0      0      MN1      W=    3.60u L=1.0u
MN7306   #3186    #3080    0      0      MN1      W=    3.60u L=1.0u
MN7305   #3185    #3138    0      0      MN1      W=    3.60u L=1.0u
MN7304   #3184    #3078    0      0      MN1      W=    3.60u L=1.0u
MN7303   #3183    #3137    0      0      MN1      W=    3.60u L=1.0u
MN7302   #3182    #3076    0      0      MN1      W=    3.60u L=1.0u
MN7301   #3181    #3136    0      0      MN1      W=    3.60u L=1.0u
MN7300   #3180    #3074    0      0      MN1      W=    3.60u L=1.0u
MN7299   #3179    #3134    0      0      MN1      W=    3.60u L=1.0u
MP7298   #3122    #3178    #3212    1      MP1      W=    3.60u L=1.0u
MP7297   #3121    #3178    #3211    1      MP1      W=    3.60u L=1.0u
MP7296   #3120    #3178    #3210    1      MP1      W=    3.60u L=1.0u
MP7295   #3119    #3178    #3209    1      MP1      W=    3.60u L=1.0u
MP7294   #3118    #3178    #3208    1      MP1      W=    3.60u L=1.0u
MP7293   #3117    #3178    #3207    1      MP1      W=    3.60u L=1.0u
MP7292   #3116    #3178    #3206    1      MP1      W=    3.60u L=1.0u
MP7291   #3115    #3178    #3205    1      MP1      W=    3.60u L=1.0u
MP7290   #3114    #3178    #3204    1      MP1      W=    3.60u L=1.0u
MP7289   #3113    #3178    #3203    1      MP1      W=    3.60u L=1.0u
MP7288   #3112    #3178    #3202    1      MP1      W=    3.60u L=1.0u
MP7287   #3111    #3178    #3201    1      MP1      W=    3.60u L=1.0u
MP7286   #3110    #3178    #3200    1      MP1      W=    3.60u L=1.0u
MP7285   #3109    #3178    #3199    1      MP1      W=    3.60u L=1.0u
MP7284   #3108    #3178    #3198    1      MP1      W=    3.60u L=1.0u
MP7283   #3107    #3178    #3197    1      MP1      W=    3.60u L=1.0u
MN7282   #3122    #3178    #3195    0      MN1      W=    3.60u L=1.0u
MN7281   #3121    #3178    #3194    0      MN1      W=    3.60u L=1.0u
MN7280   #3120    #3178    #3193    0      MN1      W=    3.60u L=1.0u
MN7279   #3119    #3178    #3192    0      MN1      W=    3.60u L=1.0u
MN7278   #3118    #3178    #3191    0      MN1      W=    3.60u L=1.0u
MN7277   #3117    #3178    #3190    0      MN1      W=    3.60u L=1.0u
MN7276   #3116    #3178    #3189    0      MN1      W=    3.60u L=1.0u
MN7275   #3115    #3178    #3188    0      MN1      W=    3.60u L=1.0u
MN7274   #3114    #3178    #3187    0      MN1      W=    3.60u L=1.0u
MN7273   #3113    #3178    #3186    0      MN1      W=    3.60u L=1.0u
MN7272   #3112    #3178    #3185    0      MN1      W=    3.60u L=1.0u
MN7271   #3111    #3178    #3184    0      MN1      W=    3.60u L=1.0u
MN7270   #3110    #3178    #3183    0      MN1      W=    3.60u L=1.0u
MN7269   #3109    #3178    #3182    0      MN1      W=    3.60u L=1.0u
MN7268   #3108    #3178    #3181    0      MN1      W=    3.60u L=1.0u
MN7267   #3107    #3178    #3180    0      MN1      W=    3.60u L=1.0u
MP7266   #3123    #3178    #3196    1      MP1      W=    3.60u L=1.0u
MN7265   #3123    #3178    #3179    0      MN1      W=    3.60u L=1.0u
MP7264   #3126    X1       1      1      MP1      W=   21.60u L=1.0u
MN7263   #3126    X1       0      0      MN1      W=    7.20u L=1.0u
MN7262   #3160    #3126    #3122    0      MN1      W=    3.60u L=1.0u
MP7261   #3177    #3126    #3122    1      MP1      W=    3.60u L=1.0u
MP7260   #3175    #3126    #3121    1      MP1      W=    3.60u L=1.0u
MN7259   #3158    #3126    #3120    0      MN1      W=    3.60u L=1.0u
MP7258   #3174    #3126    #3120    1      MP1      W=    3.60u L=1.0u
MP7257   #3173    #3126    #3119    1      MP1      W=    3.60u L=1.0u
MN7256   #3156    #3126    #3118    0      MN1      W=    3.60u L=1.0u
MP7255   #3172    #3126    #3118    1      MP1      W=    3.60u L=1.0u
MP7254   #3171    #3126    #3117    1      MP1      W=    3.60u L=1.0u
MN7253   #3154    #3126    #3116    0      MN1      W=    3.60u L=1.0u
MP7252   #3170    #3126    #3116    1      MP1      W=    3.60u L=1.0u
MP7251   #3169    #3126    #3115    1      MP1      W=    3.60u L=1.0u
MN7250   #3152    #3126    #3114    0      MN1      W=    3.60u L=1.0u
MP7249   #3168    #3126    #3114    1      MP1      W=    3.60u L=1.0u
MP7248   #3167    #3126    #3113    1      MP1      W=    3.60u L=1.0u
MN7247   #3150    #3126    #3112    0      MN1      W=    3.60u L=1.0u
MP7246   #3166    #3126    #3112    1      MP1      W=    3.60u L=1.0u
MP7245   #3165    #3126    #3111    1      MP1      W=    3.60u L=1.0u
MN7244   #3148    #3126    #3110    0      MN1      W=    3.60u L=1.0u
MP7243   #3164    #3126    #3110    1      MP1      W=    3.60u L=1.0u
MP7242   #3163    #3126    #3109    1      MP1      W=    3.60u L=1.0u
MN7241   #3146    #3126    #3108    0      MN1      W=    3.60u L=1.0u
MP7240   #3162    #3126    #3108    1      MP1      W=    3.60u L=1.0u
MP7239   #3161    #3126    #3107    1      MP1      W=    3.60u L=1.0u
MN7238   #3145    #3126    #3107    0      MN1      W=    3.60u L=1.0u
MN7237   #3159    #3126    #3121    0      MN1      W=    3.60u L=1.0u
MN7236   #3157    #3126    #3119    0      MN1      W=    3.60u L=1.0u
MN7235   #3155    #3126    #3117    0      MN1      W=    3.60u L=1.0u
MN7234   #3153    #3126    #3115    0      MN1      W=    3.60u L=1.0u
MN7233   #3151    #3126    #3113    0      MN1      W=    3.60u L=1.0u
MN7232   #3149    #3126    #3111    0      MN1      W=    3.60u L=1.0u
MN7231   #3147    #3126    #3109    0      MN1      W=    3.60u L=1.0u
MN7230   #3144    #3126    #3123    0      MN1      W=    3.60u L=1.0u
MP7229   #3176    #3126    #3123    1      MP1      W=    3.60u L=1.0u
MP7226   1      #3072    #3177    1      MP1      W=    3.60u L=1.0u
MP7225   1      #3134    #3176    1      MP1      W=    3.60u L=1.0u
MN7224   0      #3143    #3160    0      MN1      W=    3.60u L=1.0u
MP7223   1      #3071    #3175    1      MP1      W=    3.60u L=1.0u
MN7222   0      #3135    #3159    0      MN1      W=    3.60u L=1.0u
MN7221   0      #3087    #3158    0      MN1      W=    3.60u L=1.0u
MP7220   1      #3142    #3174    1      MP1      W=    3.60u L=1.0u
MP7219   1      #3086    #3173    1      MP1      W=    3.60u L=1.0u
MN7218   0      #3133    #3157    0      MN1      W=    3.60u L=1.0u
MN7217   0      #3085    #3156    0      MN1      W=    3.60u L=1.0u
MP7216   1      #3141    #3172    1      MP1      W=    3.60u L=1.0u
MP7215   1      #3084    #3171    1      MP1      W=    3.60u L=1.0u
MN7214   0      #3132    #3155    0      MN1      W=    3.60u L=1.0u
MN7213   0      #3083    #3154    0      MN1      W=    3.60u L=1.0u
MP7212   1      #3140    #3170    1      MP1      W=    3.60u L=1.0u
MP7211   1      #3082    #3169    1      MP1      W=    3.60u L=1.0u
MN7210   0      #3131    #3153    0      MN1      W=    3.60u L=1.0u
MN7209   0      #3081    #3152    0      MN1      W=    3.60u L=1.0u
MP7208   1      #3139    #3168    1      MP1      W=    3.60u L=1.0u
MP7207   1      #3080    #3167    1      MP1      W=    3.60u L=1.0u
MN7206   0      #3130    #3151    0      MN1      W=    3.60u L=1.0u
MN7205   0      #3079    #3150    0      MN1      W=    3.60u L=1.0u
MP7204   1      #3138    #3166    1      MP1      W=    3.60u L=1.0u
MP7203   1      #3078    #3165    1      MP1      W=    3.60u L=1.0u
MN7202   0      #3129    #3149    0      MN1      W=    3.60u L=1.0u
MN7201   0      #3077    #3148    0      MN1      W=    3.60u L=1.0u
MP7200   1      #3137    #3164    1      MP1      W=    3.60u L=1.0u
MP7199   1      #3076    #3163    1      MP1      W=    3.60u L=1.0u
MN7198   0      #3128    #3147    0      MN1      W=    3.60u L=1.0u
MN7197   0      #3075    #3146    0      MN1      W=    3.60u L=1.0u
MP7196   1      #3136    #3162    1      MP1      W=    3.60u L=1.0u
MP7195   1      #3074    #3161    1      MP1      W=    3.60u L=1.0u
MN7194   0      #3127    #3145    0      MN1      W=    3.60u L=1.0u
MN7193   0      #3088    #3144    0      MN1      W=    3.60u L=1.0u
MN7192   #3073    #3106    0      0      MN1      W=   14.40u L=1.0u
MP7191   #3073    #3106    1      1      MP1      W=   43.20u L=1.0u
MP7190   #3125    #3123    1      1      MP1      W=   10.80u L=1.0u
MN7189   #2847    #3122    0      0      MN1      W=   10.80u L=1.0u
MN7188   #2846    #3121    0      0      MN1      W=   10.80u L=1.0u
MN7187   #2845    #3120    0      0      MN1      W=   10.80u L=1.0u
MN7186   #2844    #3119    0      0      MN1      W=   10.80u L=1.0u
MN7185   #2843    #3118    0      0      MN1      W=   10.80u L=1.0u
MN7184   #2842    #3117    0      0      MN1      W=   10.80u L=1.0u
MN7183   #2841    #3116    0      0      MN1      W=   10.80u L=1.0u
MN7182   #2840    #3115    0      0      MN1      W=   10.80u L=1.0u
MN7181   #2839    #3114    0      0      MN1      W=   10.80u L=1.0u
MN7180   #2838    #3113    0      0      MN1      W=   10.80u L=1.0u
MN7179   #2837    #3112    0      0      MN1      W=   10.80u L=1.0u
MN7178   #2836    #3111    0      0      MN1      W=   10.80u L=1.0u
MN7177   #2835    #3110    0      0      MN1      W=   10.80u L=1.0u
MN7176   #2834    #3109    0      0      MN1      W=   10.80u L=1.0u
MN7175   #2833    #3108    0      0      MN1      W=   10.80u L=1.0u
MN7174   #3124    #3107    0      0      MN1      W=   10.80u L=1.0u
MN7173   #3125    #3123    0      0      MN1      W=   10.80u L=1.0u
MP7172   #2847    #3122    1      1      MP1      W=   10.80u L=1.0u
MP7171   #2846    #3121    1      1      MP1      W=   10.80u L=1.0u
MP7170   #2845    #3120    1      1      MP1      W=   10.80u L=1.0u
MP7169   #2844    #3119    1      1      MP1      W=   10.80u L=1.0u
MP7168   #2843    #3118    1      1      MP1      W=   10.80u L=1.0u
MP7167   #2842    #3117    1      1      MP1      W=   10.80u L=1.0u
MP7166   #2841    #3116    1      1      MP1      W=   10.80u L=1.0u
MP7165   #2840    #3115    1      1      MP1      W=   10.80u L=1.0u
MP7164   #2839    #3114    1      1      MP1      W=   10.80u L=1.0u
MP7163   #2838    #3113    1      1      MP1      W=   10.80u L=1.0u
MP7162   #2837    #3112    1      1      MP1      W=   10.80u L=1.0u
MP7161   #2836    #3111    1      1      MP1      W=   10.80u L=1.0u
MP7160   #2835    #3110    1      1      MP1      W=   10.80u L=1.0u
MP7159   #2834    #3109    1      1      MP1      W=   10.80u L=1.0u
MP7158   #2833    #3108    1      1      MP1      W=   10.80u L=1.0u
MP7157   #3124    #3107    1      1      MP1      W=   10.80u L=1.0u
MP7118   #3040    #3073    1      1      MP1      W=    3.60u L=1.0u
MP7117   #3039    #3073    1      1      MP1      W=    3.60u L=1.0u
MP7116   #3055    #3073    1      1      MP1      W=    3.60u L=1.0u
MP7115   #3054    #3073    1      1      MP1      W=    3.60u L=1.0u
MP7114   #3053    #3073    1      1      MP1      W=    3.60u L=1.0u
MP7113   #3052    #3073    1      1      MP1      W=    3.60u L=1.0u
MP7112   #3051    #3073    1      1      MP1      W=    3.60u L=1.0u
MP7111   #3050    #3073    1      1      MP1      W=    3.60u L=1.0u
MP7110   #3049    #3073    1      1      MP1      W=    3.60u L=1.0u
MP7109   #3048    #3073    1      1      MP1      W=    3.60u L=1.0u
MP7108   #3047    #3073    1      1      MP1      W=    3.60u L=1.0u
MP7107   #3046    #3073    1      1      MP1      W=    3.60u L=1.0u
MP7106   #3045    #3073    1      1      MP1      W=    3.60u L=1.0u
MP7105   #3044    #3073    1      1      MP1      W=    3.60u L=1.0u
MP7104   #3043    #3073    1      1      MP1      W=    3.60u L=1.0u
MP7103   #3042    #3073    1      1      MP1      W=    3.60u L=1.0u
MP7102   #3088    #3037    1      1      MP1      W=    3.60u L=1.0u
MN7101   #3105    #3037    0      0      MN1      W=    3.60u L=1.0u
MN7100   #3104    #3037    0      0      MN1      W=    3.60u L=1.0u
MN7099   #3103    #3037    0      0      MN1      W=    3.60u L=1.0u
MN7098   #3102    #3037    0      0      MN1      W=    3.60u L=1.0u
MN7097   #3101    #3037    0      0      MN1      W=    3.60u L=1.0u
MN7096   #3100    #3037    0      0      MN1      W=    3.60u L=1.0u
MN7095   #3099    #3037    0      0      MN1      W=    3.60u L=1.0u
MN7094   #3098    #3037    0      0      MN1      W=    3.60u L=1.0u
MN7093   #3097    #3037    0      0      MN1      W=    3.60u L=1.0u
MN7092   #3096    #3037    0      0      MN1      W=    3.60u L=1.0u
MN7091   #3095    #3037    0      0      MN1      W=    3.60u L=1.0u
MN7090   #3094    #3037    0      0      MN1      W=    3.60u L=1.0u
MN7089   #3093    #3037    0      0      MN1      W=    3.60u L=1.0u
MN7088   #3092    #3037    0      0      MN1      W=    3.60u L=1.0u
MN7087   #3091    #3037    0      0      MN1      W=    3.60u L=1.0u
MN7086   #3090    #3037    0      0      MN1      W=    3.60u L=1.0u
MN7083   #3089    #3037    0      0      MN1      W=    3.60u L=1.0u
MP7082   #3087    #51      #3055    1      MP1      W=    3.60u L=1.0u
MP7081   #3086    #50      #3054    1      MP1      W=    3.60u L=1.0u
MP7080   #3085    #49      #3053    1      MP1      W=    3.60u L=1.0u
MP7079   #3084    #48      #3052    1      MP1      W=    3.60u L=1.0u
MP7078   #3083    #47      #3051    1      MP1      W=    3.60u L=1.0u
MP7077   #3082    #46      #3050    1      MP1      W=    3.60u L=1.0u
MP7076   #3081    #45      #3049    1      MP1      W=    3.60u L=1.0u
MP7075   #3080    #44      #3048    1      MP1      W=    3.60u L=1.0u
MP7074   #3079    #43      #3047    1      MP1      W=    3.60u L=1.0u
MP7073   #3078    #42      #3046    1      MP1      W=    3.60u L=1.0u
MP7072   #3077    #41      #3045    1      MP1      W=    3.60u L=1.0u
MP7071   #3076    #40      #3044    1      MP1      W=    3.60u L=1.0u
MP7070   #3075    #39      #3043    1      MP1      W=    3.60u L=1.0u
MP7069   #3074    #38      #3042    1      MP1      W=    3.60u L=1.0u
MN7068   #3071    #52      #3105    0      MN1      W=    3.60u L=1.0u
MN7067   #3087    #51      #3104    0      MN1      W=    3.60u L=1.0u
MN7066   #3086    #50      #3103    0      MN1      W=    3.60u L=1.0u
MN7065   #3085    #49      #3102    0      MN1      W=    3.60u L=1.0u
MN7064   #3084    #48      #3101    0      MN1      W=    3.60u L=1.0u
MN7063   #3083    #47      #3100    0      MN1      W=    3.60u L=1.0u
MN7062   #3082    #46      #3099    0      MN1      W=    3.60u L=1.0u
MN7061   #3081    #45      #3098    0      MN1      W=    3.60u L=1.0u
MN7060   #3080    #44      #3097    0      MN1      W=    3.60u L=1.0u
MN7059   #3079    #43      #3096    0      MN1      W=    3.60u L=1.0u
MN7058   #3078    #42      #3095    0      MN1      W=    3.60u L=1.0u
MN7057   #3077    #41      #3094    0      MN1      W=    3.60u L=1.0u
MN7056   #3076    #40      #3093    0      MN1      W=    3.60u L=1.0u
MN7055   #3075    #39      #3092    0      MN1      W=    3.60u L=1.0u
MN7054   #3074    #38      #3091    0      MN1      W=    3.60u L=1.0u
MN7053   #3088    #37      #3090    0      MN1      W=    3.60u L=1.0u
MP7052   1      #37      #3088    1      MP1      W=    3.60u L=1.0u
MP7051   #3071    #52      #3039    1      MP1      W=    3.60u L=1.0u
MP7050   #3072    #52      #3040    1      MP1      W=    3.60u L=1.0u
MN7049   #3037    #3038    0      0      MN1      W=   14.40u L=1.0u
MN7048   #3072    #52      #3089    0      MN1      W=    3.60u L=1.0u
MP7047   #3037    #3038    1      1      MP1      W=   43.20u L=1.0u
MN7046   #3070    #3073    #3071    0      MN1      W=    3.60u L=1.0u
MN7045   #3069    #3073    #3087    0      MN1      W=    3.60u L=1.0u
MN7044   #3068    #3073    #3086    0      MN1      W=    3.60u L=1.0u
MN7043   #3067    #3073    #3085    0      MN1      W=    3.60u L=1.0u
MN7042   #3066    #3073    #3084    0      MN1      W=    3.60u L=1.0u
MN7041   #3065    #3073    #3083    0      MN1      W=    3.60u L=1.0u
MN7040   #3064    #3073    #3082    0      MN1      W=    3.60u L=1.0u
MN7039   #3063    #3073    #3081    0      MN1      W=    3.60u L=1.0u
MN7038   #3062    #3073    #3080    0      MN1      W=    3.60u L=1.0u
MN7037   #3061    #3073    #3079    0      MN1      W=    3.60u L=1.0u
MN7036   #3060    #3073    #3078    0      MN1      W=    3.60u L=1.0u
MN7035   #3059    #3073    #3077    0      MN1      W=    3.60u L=1.0u
MN7034   #3058    #3073    #3076    0      MN1      W=    3.60u L=1.0u
MN7033   #3057    #3073    #3075    0      MN1      W=    3.60u L=1.0u
MP7032   #3055    #3037    #3087    1      MP1      W=    3.60u L=1.0u
MP7031   #3054    #3037    #3086    1      MP1      W=    3.60u L=1.0u
MP7030   #3053    #3037    #3085    1      MP1      W=    3.60u L=1.0u
MP7029   #3052    #3037    #3084    1      MP1      W=    3.60u L=1.0u
MP7028   #3051    #3037    #3083    1      MP1      W=    3.60u L=1.0u
MP7027   #3050    #3037    #3082    1      MP1      W=    3.60u L=1.0u
MP7026   #3049    #3037    #3081    1      MP1      W=    3.60u L=1.0u
MP7025   #3048    #3037    #3080    1      MP1      W=    3.60u L=1.0u
MP7024   #3047    #3037    #3079    1      MP1      W=    3.60u L=1.0u
MP7023   #3046    #3037    #3078    1      MP1      W=    3.60u L=1.0u
MP7022   #3045    #3037    #3077    1      MP1      W=    3.60u L=1.0u
MP7021   #3044    #3037    #3076    1      MP1      W=    3.60u L=1.0u
MP7020   #3043    #3037    #3075    1      MP1      W=    3.60u L=1.0u
MP7019   #3042    #3037    #3074    1      MP1      W=    3.60u L=1.0u
MN7018   #3056    #3073    #3074    0      MN1      W=    3.60u L=1.0u
MN7017   #3041    #3073    #3072    0      MN1      W=    3.60u L=1.0u
MP7014   #3040    #3037    #3072    1      MP1      W=    3.60u L=1.0u
MP7013   #3039    #3037    #3071    1      MP1      W=    3.60u L=1.0u
MN7012   0      #51      #3070    0      MN1      W=    3.60u L=1.0u
MN7011   0      #50      #3069    0      MN1      W=    3.60u L=1.0u
MN7010   0      #49      #3068    0      MN1      W=    3.60u L=1.0u
MN7009   0      #48      #3067    0      MN1      W=    3.60u L=1.0u
MN7008   0      #47      #3066    0      MN1      W=    3.60u L=1.0u
MN7007   0      #46      #3065    0      MN1      W=    3.60u L=1.0u
MN7006   0      #45      #3064    0      MN1      W=    3.60u L=1.0u
MN7005   0      #44      #3063    0      MN1      W=    3.60u L=1.0u
MN7004   0      #43      #3062    0      MN1      W=    3.60u L=1.0u
MN7003   0      #42      #3061    0      MN1      W=    3.60u L=1.0u
MN7002   0      #41      #3060    0      MN1      W=    3.60u L=1.0u
MN7001   0      #40      #3059    0      MN1      W=    3.60u L=1.0u
MN7000   0      #39      #3058    0      MN1      W=    3.60u L=1.0u
MN6999   0      #38      #3057    0      MN1      W=    3.60u L=1.0u
MN6998   0      #37      #3056    0      MN1      W=    3.60u L=1.0u
MP6997   1      #50      #3055    1      MP1      W=    3.60u L=1.0u
MP6996   1      #49      #3054    1      MP1      W=    3.60u L=1.0u
MP6995   1      #48      #3053    1      MP1      W=    3.60u L=1.0u
MP6994   1      #47      #3052    1      MP1      W=    3.60u L=1.0u
MP6993   1      #46      #3051    1      MP1      W=    3.60u L=1.0u
MP6992   1      #45      #3050    1      MP1      W=    3.60u L=1.0u
MP6991   1      #44      #3049    1      MP1      W=    3.60u L=1.0u
MP6990   1      #43      #3048    1      MP1      W=    3.60u L=1.0u
MP6989   1      #42      #3047    1      MP1      W=    3.60u L=1.0u
MP6988   1      #41      #3046    1      MP1      W=    3.60u L=1.0u
MP6987   1      #40      #3045    1      MP1      W=    3.60u L=1.0u
MP6986   1      #39      #3044    1      MP1      W=    3.60u L=1.0u
MP6985   1      #38      #3043    1      MP1      W=    3.60u L=1.0u
MP6984   1      #37      #3042    1      MP1      W=    3.60u L=1.0u
MN6983   0      #52      #3041    0      MN1      W=    3.60u L=1.0u
MP6982   1      #52      #3040    1      MP1      W=    3.60u L=1.0u
MP6981   1      #51      #3039    1      MP1      W=    3.60u L=1.0u
MN6978   #3022    #2939    0      0      MN1      W=   10.80u L=1.0u
MP6977   #3022    #2939    1      1      MP1      W=   10.80u L=1.0u
MN6976   #3029    #2946    0      0      MN1      W=   10.80u L=1.0u
MN6975   #3036    #2953    0      0      MN1      W=   10.80u L=1.0u
MN6974   #3028    #2945    0      0      MN1      W=   10.80u L=1.0u
MN6973   #3035    #2952    0      0      MN1      W=   10.80u L=1.0u
MN6972   #3027    #2944    0      0      MN1      W=   10.80u L=1.0u
MN6971   #3034    #2951    0      0      MN1      W=   10.80u L=1.0u
MN6970   #3026    #2943    0      0      MN1      W=   10.80u L=1.0u
MN6969   #3033    #2950    0      0      MN1      W=   10.80u L=1.0u
MN6968   #3025    #2942    0      0      MN1      W=   10.80u L=1.0u
MN6967   #3032    #2949    0      0      MN1      W=   10.80u L=1.0u
MN6966   #3024    #2941    0      0      MN1      W=   10.80u L=1.0u
MN6965   #3031    #2948    0      0      MN1      W=   10.80u L=1.0u
MN6964   #3023    #2940    0      0      MN1      W=   10.80u L=1.0u
MN6963   #3030    #2947    0      0      MN1      W=   10.80u L=1.0u
MP6962   #3029    #2946    1      1      MP1      W=   10.80u L=1.0u
MP6961   #3036    #2953    1      1      MP1      W=   10.80u L=1.0u
MP6960   #3028    #2945    1      1      MP1      W=   10.80u L=1.0u
MP6959   #3035    #2952    1      1      MP1      W=   10.80u L=1.0u
MP6958   #3027    #2944    1      1      MP1      W=   10.80u L=1.0u
MP6957   #3034    #2951    1      1      MP1      W=   10.80u L=1.0u
MP6956   #3026    #2943    1      1      MP1      W=   10.80u L=1.0u
MP6955   #3033    #2950    1      1      MP1      W=   10.80u L=1.0u
MP6954   #3025    #2942    1      1      MP1      W=   10.80u L=1.0u
MP6953   #3032    #2949    1      1      MP1      W=   10.80u L=1.0u
MP6952   #3024    #2941    1      1      MP1      W=   10.80u L=1.0u
MP6951   #3031    #2948    1      1      MP1      W=   10.80u L=1.0u
MP6950   #3023    #2940    1      1      MP1      W=   10.80u L=1.0u
MP6949   #3030    #2947    1      1      MP1      W=   10.80u L=1.0u
MN6930   0      #2866    #3002    0      MN1      W=    1.80u L=1.0u
MN6915   Z17      #2954    0      0      MN1      W=    3.60u L=1.0u
MP6914   #3021    #2867    1      1      MP1      W=    1.80u L=1.0u
MP6913   Z17      #2954    1      1      MP1      W=    3.60u L=1.0u
MN6912   #2987    #2833    0      0      MN1      W=    5.40u L=1.0u
MP6911   #3018    #2833    1      1      MP1      W=    5.40u L=1.0u
MN6910   #3002    #2867    0      0      MN1      W=    1.80u L=1.0u
MN6909   #3001    #2847    0      0      MN1      W=    5.40u L=1.0u
MN6908   #2999    #2845    0      0      MN1      W=    5.40u L=1.0u
MN6907   #2997    #2843    0      0      MN1      W=    5.40u L=1.0u
MN6906   #2995    #2841    0      0      MN1      W=    5.40u L=1.0u
MN6905   #2993    #2839    0      0      MN1      W=    5.40u L=1.0u
MN6904   #2991    #2837    0      0      MN1      W=    5.40u L=1.0u
MN6903   #2989    #2835    0      0      MN1      W=    5.40u L=1.0u
MP6902   #3017    #2847    1      1      MP1      W=    5.40u L=1.0u
MP6901   #3015    #2845    1      1      MP1      W=    5.40u L=1.0u
MP6900   #3013    #2843    1      1      MP1      W=    5.40u L=1.0u
MP6899   #3011    #2841    1      1      MP1      W=    5.40u L=1.0u
MP6898   #3009    #2839    1      1      MP1      W=    5.40u L=1.0u
MP6897   #3007    #2837    1      1      MP1      W=    5.40u L=1.0u
MP6896   #3005    #2835    1      1      MP1      W=    5.40u L=1.0u
MP6895   #3019    #2604    1      1      MP1      W=    5.40u L=1.0u
MP6894   #2954    #2866    #3021    1      MP1      W=    1.80u L=1.0u
MP6893   #3016    #2846    1      1      MP1      W=    5.40u L=1.0u
MP6892   #3014    #2844    1      1      MP1      W=    5.40u L=1.0u
MP6891   #3012    #2842    1      1      MP1      W=    5.40u L=1.0u
MP6890   #3010    #2840    1      1      MP1      W=    5.40u L=1.0u
MP6889   #3008    #2838    1      1      MP1      W=    5.40u L=1.0u
MP6888   #3006    #2836    1      1      MP1      W=    5.40u L=1.0u
MP6887   #3004    #2834    1      1      MP1      W=    5.40u L=1.0u
MN6886   #3000    #2846    0      0      MN1      W=    5.40u L=1.0u
MN6885   #2998    #2844    0      0      MN1      W=    5.40u L=1.0u
MN6884   #2996    #2842    0      0      MN1      W=    5.40u L=1.0u
MN6883   #2994    #2840    0      0      MN1      W=    5.40u L=1.0u
MN6882   #2992    #2838    0      0      MN1      W=    5.40u L=1.0u
MN6881   #2990    #2836    0      0      MN1      W=    5.40u L=1.0u
MN6880   #2988    #2834    0      0      MN1      W=    5.40u L=1.0u
MN6879   #3003    #2604    0      0      MN1      W=    5.40u L=1.0u
MP6878   #2986    #2830    #3019    1      MP1      W=    5.40u L=1.0u
MP6877   #2984    #2701    #3018    1      MP1      W=    5.40u L=1.0u
MP6876   #2983    #2603    #3017    1      MP1      W=    5.40u L=1.0u
MP6875   #2982    #2610    #3016    1      MP1      W=    5.40u L=1.0u
MP6874   #2981    #2602    #3015    1      MP1      W=    5.40u L=1.0u
MP6873   #2980    #2609    #3014    1      MP1      W=    5.40u L=1.0u
MP6872   #2979    #2601    #3013    1      MP1      W=    5.40u L=1.0u
MP6871   #2978    #2608    #3012    1      MP1      W=    5.40u L=1.0u
MP6870   #2977    #2600    #3011    1      MP1      W=    5.40u L=1.0u
MP6869   #2976    #2607    #3010    1      MP1      W=    5.40u L=1.0u
MP6868   #2975    #2599    #3009    1      MP1      W=    5.40u L=1.0u
MP6867   #2974    #2606    #3008    1      MP1      W=    5.40u L=1.0u
MP6866   #2973    #2598    #3007    1      MP1      W=    5.40u L=1.0u
MP6865   #2972    #2605    #3006    1      MP1      W=    5.40u L=1.0u
MP6864   #2971    #2597    #3005    1      MP1      W=    5.40u L=1.0u
MP6863   #2970    #2699    #3004    1      MP1      W=    5.40u L=1.0u
MN6862   #2985    #2830    #3003    0      MN1      W=    5.40u L=1.0u
MN6861   #2954    #2936    #3002    0      MN1      W=    1.80u L=1.0u
MN6860   #2969    #2603    #3001    0      MN1      W=    5.40u L=1.0u
MN6859   #2968    #2610    #3000    0      MN1      W=    5.40u L=1.0u
MN6858   #2967    #2602    #2999    0      MN1      W=    5.40u L=1.0u
MN6857   #2966    #2609    #2998    0      MN1      W=    5.40u L=1.0u
MN6856   #2965    #2601    #2997    0      MN1      W=    5.40u L=1.0u
MN6855   #2964    #2608    #2996    0      MN1      W=    5.40u L=1.0u
MN6854   #2963    #2600    #2995    0      MN1      W=    5.40u L=1.0u
MN6853   #2962    #2607    #2994    0      MN1      W=    5.40u L=1.0u
MN6852   #2961    #2599    #2993    0      MN1      W=    5.40u L=1.0u
MN6851   #2960    #2606    #2992    0      MN1      W=    5.40u L=1.0u
MN6850   #2959    #2598    #2991    0      MN1      W=    5.40u L=1.0u
MN6849   #2958    #2605    #2990    0      MN1      W=    5.40u L=1.0u
MN6848   #2957    #2597    #2989    0      MN1      W=    5.40u L=1.0u
MN6847   #2956    #2699    #2988    0      MN1      W=    5.40u L=1.0u
MN6846   #2955    #2701    #2987    0      MN1      W=    5.40u L=1.0u
MP6845   1      #2936    #2954    1      MP1      W=    1.80u L=1.0u
MN6844   Z18      #2936    #2985    0      MN1      W=    5.40u L=1.0u
MP6843   Z18      #2936    #2986    1      MP1      W=    5.40u L=1.0u
MP6842   #2939    #2700    #2984    1      MP1      W=    1.80u L=1.0u
MN6841   #2946    #2865    #2969    0      MN1      W=    1.80u L=1.0u
MP6840   #2946    #2865    #2983    1      MP1      W=    1.80u L=1.0u
MP6839   #2953    #2864    #2982    1      MP1      W=    1.80u L=1.0u
MN6838   #2953    #2864    #2968    0      MN1      W=    1.80u L=1.0u
MN6837   #2945    #2863    #2967    0      MN1      W=    1.80u L=1.0u
MP6836   #2945    #2863    #2981    1      MP1      W=    1.80u L=1.0u
MP6835   #2952    #2862    #2980    1      MP1      W=    1.80u L=1.0u
MN6834   #2952    #2862    #2966    0      MN1      W=    1.80u L=1.0u
MN6833   #2944    #2861    #2965    0      MN1      W=    1.80u L=1.0u
MP6832   #2944    #2861    #2979    1      MP1      W=    1.80u L=1.0u
MP6831   #2951    #2860    #2978    1      MP1      W=    1.80u L=1.0u
MN6830   #2951    #2860    #2964    0      MN1      W=    1.80u L=1.0u
MN6829   #2943    #2859    #2963    0      MN1      W=    1.80u L=1.0u
MP6828   #2943    #2859    #2977    1      MP1      W=    1.80u L=1.0u
MP6827   #2950    #2858    #2976    1      MP1      W=    1.80u L=1.0u
MN6826   #2950    #2858    #2962    0      MN1      W=    1.80u L=1.0u
MN6825   #2942    #2857    #2961    0      MN1      W=    1.80u L=1.0u
MP6824   #2942    #2857    #2975    1      MP1      W=    1.80u L=1.0u
MP6823   #2949    #2856    #2974    1      MP1      W=    1.80u L=1.0u
MN6822   #2949    #2856    #2960    0      MN1      W=    1.80u L=1.0u
MN6821   #2941    #2855    #2959    0      MN1      W=    1.80u L=1.0u
MP6820   #2941    #2855    #2973    1      MP1      W=    1.80u L=1.0u
MP6819   #2948    #2854    #2972    1      MP1      W=    1.80u L=1.0u
MN6818   #2948    #2854    #2958    0      MN1      W=    1.80u L=1.0u
MN6817   #2940    #2853    #2957    0      MN1      W=    1.80u L=1.0u
MP6816   #2940    #2853    #2971    1      MP1      W=    1.80u L=1.0u
MP6815   #2947    #2852    #2970    1      MP1      W=    1.80u L=1.0u
MN6814   #2947    #2852    #2956    0      MN1      W=    1.80u L=1.0u
MN6813   #2939    #2700    #2955    0      MN1      W=    1.80u L=1.0u
MP6812   #2903    #2904    Z18      1      MP1      W=    1.80u L=1.0u
MP6811   #2936    #2866    1      1      MP1      W=    1.80u L=1.0u
MN6810   #2902    #2904    Z18      0      MN1      W=    1.80u L=1.0u
MN6809   #2918    #2865    #2953    0      MN1      W=    1.80u L=1.0u
MN6808   #2916    #2863    #2952    0      MN1      W=    1.80u L=1.0u
MN6807   #2914    #2861    #2951    0      MN1      W=    1.80u L=1.0u
MN6806   #2912    #2859    #2950    0      MN1      W=    1.80u L=1.0u
MN6805   #2910    #2857    #2949    0      MN1      W=    1.80u L=1.0u
MN6804   #2908    #2855    #2948    0      MN1      W=    1.80u L=1.0u
MN6803   #2906    #2853    #2947    0      MN1      W=    1.80u L=1.0u
MP6802   #2934    #2852    #2939    1      MP1      W=    1.80u L=1.0u
MP6801   #2933    #2788    #2946    1      MP1      W=    1.80u L=1.0u
MP6800   #2932    #2865    #2953    1      MP1      W=    1.80u L=1.0u
MP6799   #2931    #2864    #2945    1      MP1      W=    1.80u L=1.0u
MP6798   #2930    #2863    #2952    1      MP1      W=    1.80u L=1.0u
MP6797   #2929    #2862    #2944    1      MP1      W=    1.80u L=1.0u
MP6796   #2928    #2861    #2951    1      MP1      W=    1.80u L=1.0u
MP6795   #2927    #2860    #2943    1      MP1      W=    1.80u L=1.0u
MP6794   #2926    #2859    #2950    1      MP1      W=    1.80u L=1.0u
MP6793   #2925    #2858    #2942    1      MP1      W=    1.80u L=1.0u
MP6792   #2924    #2857    #2949    1      MP1      W=    1.80u L=1.0u
MP6791   #2923    #2856    #2941    1      MP1      W=    1.80u L=1.0u
MP6790   #2922    #2855    #2948    1      MP1      W=    1.80u L=1.0u
MP6789   #2921    #2854    #2940    1      MP1      W=    1.80u L=1.0u
MP6788   #2920    #2853    #2947    1      MP1      W=    1.80u L=1.0u
MN6787   #2919    #2788    #2946    0      MN1      W=    1.80u L=1.0u
MN6786   #2917    #2864    #2945    0      MN1      W=    1.80u L=1.0u
MN6785   #2915    #2862    #2944    0      MN1      W=    1.80u L=1.0u
MN6784   #2913    #2860    #2943    0      MN1      W=    1.80u L=1.0u
MN6783   #2911    #2858    #2942    0      MN1      W=    1.80u L=1.0u
MN6782   #2909    #2856    #2941    0      MN1      W=    1.80u L=1.0u
MN6781   #2907    #2854    #2940    0      MN1      W=    1.80u L=1.0u
MN6780   #2905    #2852    #2939    0      MN1      W=    1.80u L=1.0u
MP6779   #2935    X1       1      1      MP1      W=   10.80u L=1.0u
MN6778   #2938    X1       #2935    0      MN1      W=    3.60u L=1.0u
MN6777   #2937    #2866    #2936    0      MN1      W=    1.80u L=1.0u
MN6776   0      #2864    #2918    0      MN1      W=    1.80u L=1.0u
MN6775   0      #2862    #2916    0      MN1      W=    1.80u L=1.0u
MN6774   0      #2860    #2914    0      MN1      W=    1.80u L=1.0u
MN6773   0      #2858    #2912    0      MN1      W=    1.80u L=1.0u
MN6772   0      #2856    #2910    0      MN1      W=    1.80u L=1.0u
MN6771   0      #2854    #2908    0      MN1      W=    1.80u L=1.0u
MN6770   0      #2852    #2906    0      MN1      W=    1.80u L=1.0u
MP6769   1      #2700    #2934    1      MP1      W=    1.80u L=1.0u
MN6768   0      #2865    #2919    0      MN1      W=    1.80u L=1.0u
MP6767   1      #2865    #2933    1      MP1      W=    1.80u L=1.0u
MP6766   1      #2864    #2932    1      MP1      W=    1.80u L=1.0u
MN6765   0      #2863    #2917    0      MN1      W=    1.80u L=1.0u
MP6764   1      #2863    #2931    1      MP1      W=    1.80u L=1.0u
MP6763   1      #2862    #2930    1      MP1      W=    1.80u L=1.0u
MN6762   0      #2861    #2915    0      MN1      W=    1.80u L=1.0u
MP6761   1      #2861    #2929    1      MP1      W=    1.80u L=1.0u
MP6760   1      #2860    #2928    1      MP1      W=    1.80u L=1.0u
MN6759   0      #2859    #2913    0      MN1      W=    1.80u L=1.0u
MP6758   1      #2859    #2927    1      MP1      W=    1.80u L=1.0u
MP6757   1      #2858    #2926    1      MP1      W=    1.80u L=1.0u
MN6756   0      #2857    #2911    0      MN1      W=    1.80u L=1.0u
MP6755   1      #2857    #2925    1      MP1      W=    1.80u L=1.0u
MP6754   1      #2856    #2924    1      MP1      W=    1.80u L=1.0u
MN6753   0      #2855    #2909    0      MN1      W=    1.80u L=1.0u
MP6752   1      #2855    #2923    1      MP1      W=    1.80u L=1.0u
MP6751   1      #2854    #2922    1      MP1      W=    1.80u L=1.0u
MN6750   0      #2853    #2907    0      MN1      W=    1.80u L=1.0u
MP6749   1      #2853    #2921    1      MP1      W=    1.80u L=1.0u
MP6748   1      #2852    #2920    1      MP1      W=    1.80u L=1.0u
MN6747   0      #2700    #2905    0      MN1      W=    1.80u L=1.0u
MN6746   0      #2936    #2902    0      MN1      W=    5.40u L=1.0u
MP6745   1      #2936    #2903    1      MP1      W=    5.40u L=1.0u
MP6744   1      X2       #2935    1      MP1      W=   10.80u L=1.0u
MP6743   1      #2867    #2936    1      MP1      W=    1.80u L=1.0u
MN6742   0      X2       #2938    0      MN1      W=    3.60u L=1.0u
MN6741   0      #2867    #2937    0      MN1      W=    1.80u L=1.0u
MP6740   #2934    #2701    1      1      MP1      W=    5.40u L=1.0u
MP6739   #2933    #2603    1      1      MP1      W=    5.40u L=1.0u
MP6738   #2932    #2610    1      1      MP1      W=    5.40u L=1.0u
MP6737   #2931    #2602    1      1      MP1      W=    5.40u L=1.0u
MP6736   #2930    #2609    1      1      MP1      W=    5.40u L=1.0u
MP6735   #2929    #2601    1      1      MP1      W=    5.40u L=1.0u
MP6734   #2928    #2608    1      1      MP1      W=    5.40u L=1.0u
MP6733   #2927    #2600    1      1      MP1      W=    5.40u L=1.0u
MP6732   #2926    #2607    1      1      MP1      W=    5.40u L=1.0u
MP6731   #2925    #2599    1      1      MP1      W=    5.40u L=1.0u
MP6730   #2924    #2606    1      1      MP1      W=    5.40u L=1.0u
MP6729   #2923    #2598    1      1      MP1      W=    5.40u L=1.0u
MP6728   #2922    #2605    1      1      MP1      W=    5.40u L=1.0u
MP6727   #2921    #2597    1      1      MP1      W=    5.40u L=1.0u
MP6726   #2920    #2699    1      1      MP1      W=    5.40u L=1.0u
MN6725   #2919    #2603    0      0      MN1      W=    5.40u L=1.0u
MN6724   #2918    #2610    0      0      MN1      W=    5.40u L=1.0u
MN6723   #2917    #2602    0      0      MN1      W=    5.40u L=1.0u
MN6722   #2916    #2609    0      0      MN1      W=    5.40u L=1.0u
MN6721   #2915    #2601    0      0      MN1      W=    5.40u L=1.0u
MN6720   #2914    #2608    0      0      MN1      W=    5.40u L=1.0u
MN6719   #2913    #2600    0      0      MN1      W=    5.40u L=1.0u
MN6718   #2912    #2607    0      0      MN1      W=    5.40u L=1.0u
MN6717   #2911    #2599    0      0      MN1      W=    5.40u L=1.0u
MN6716   #2910    #2606    0      0      MN1      W=    5.40u L=1.0u
MN6715   #2909    #2598    0      0      MN1      W=    5.40u L=1.0u
MN6714   #2908    #2605    0      0      MN1      W=    5.40u L=1.0u
MN6713   #2907    #2597    0      0      MN1      W=    5.40u L=1.0u
MN6712   #2906    #2699    0      0      MN1      W=    5.40u L=1.0u
MN6711   #2905    #2701    0      0      MN1      W=    5.40u L=1.0u
MN6710   #2869    #2935    0      0      MN1      W=    3.60u L=1.0u
MN6709   #2904    #2406    0      0      MN1      W=    1.80u L=1.0u
MP6708   #2612    #2935    1      1      MP1      W=   10.80u L=1.0u
MP6707   #2903    #2604    1      1      MP1      W=    5.40u L=1.0u
MP6706   #2904    #2406    1      1      MP1      W=    1.80u L=1.0u
MN6705   #2902    #2604    0      0      MN1      W=    5.40u L=1.0u
MP6704   1      #2833    #2934    1      MP1      W=    5.40u L=1.0u
MN6703   0      #2847    #2919    0      MN1      W=    5.40u L=1.0u
MP6702   1      #2847    #2933    1      MP1      W=    5.40u L=1.0u
MP6701   1      #2846    #2932    1      MP1      W=    5.40u L=1.0u
MN6700   0      #2846    #2918    0      MN1      W=    5.40u L=1.0u
MN6699   0      #2845    #2917    0      MN1      W=    5.40u L=1.0u
MP6698   1      #2845    #2931    1      MP1      W=    5.40u L=1.0u
MP6697   1      #2844    #2930    1      MP1      W=    5.40u L=1.0u
MN6696   0      #2844    #2916    0      MN1      W=    5.40u L=1.0u
MN6695   0      #2843    #2915    0      MN1      W=    5.40u L=1.0u
MP6694   1      #2843    #2929    1      MP1      W=    5.40u L=1.0u
MP6693   1      #2842    #2928    1      MP1      W=    5.40u L=1.0u
MN6692   0      #2842    #2914    0      MN1      W=    5.40u L=1.0u
MN6691   0      #2841    #2913    0      MN1      W=    5.40u L=1.0u
MP6690   1      #2841    #2927    1      MP1      W=    5.40u L=1.0u
MP6689   1      #2840    #2926    1      MP1      W=    5.40u L=1.0u
MN6688   0      #2840    #2912    0      MN1      W=    5.40u L=1.0u
MN6687   0      #2839    #2911    0      MN1      W=    5.40u L=1.0u
MP6686   1      #2839    #2925    1      MP1      W=    5.40u L=1.0u
MP6685   1      #2838    #2924    1      MP1      W=    5.40u L=1.0u
MN6684   0      #2838    #2910    0      MN1      W=    5.40u L=1.0u
MN6683   0      #2837    #2909    0      MN1      W=    5.40u L=1.0u
MP6682   1      #2837    #2923    1      MP1      W=    5.40u L=1.0u
MP6681   1      #2836    #2922    1      MP1      W=    5.40u L=1.0u
MN6680   0      #2836    #2908    0      MN1      W=    5.40u L=1.0u
MN6679   0      #2835    #2907    0      MN1      W=    5.40u L=1.0u
MP6678   1      #2835    #2921    1      MP1      W=    5.40u L=1.0u
MP6677   1      #2834    #2920    1      MP1      W=    5.40u L=1.0u
MN6676   0      #2834    #2906    0      MN1      W=    5.40u L=1.0u
MN6675   0      #2833    #2905    0      MN1      W=    5.40u L=1.0u
MN6674   #2612    X2       #2869    0      MN1      W=    3.60u L=1.0u
MP6673   #2901    X2       #2612    1      MP1      W=   10.80u L=1.0u
MP6672   1      #2830    #2903    1      MP1      W=    5.40u L=1.0u
MN6671   0      #2830    #2902    0      MN1      W=    5.40u L=1.0u
MP6670   #2885    #2833    1      1      MP1      W=    5.40u L=1.0u
MP6669   #2899    #2847    1      1      MP1      W=    5.40u L=1.0u
MP6668   #2898    #2846    1      1      MP1      W=    5.40u L=1.0u
MP6667   #2897    #2845    1      1      MP1      W=    5.40u L=1.0u
MP6666   #2896    #2844    1      1      MP1      W=    5.40u L=1.0u
MP6665   #2895    #2843    1      1      MP1      W=    5.40u L=1.0u
MP6664   #2894    #2842    1      1      MP1      W=    5.40u L=1.0u
MP6663   #2893    #2841    1      1      MP1      W=    5.40u L=1.0u
MP6662   #2892    #2840    1      1      MP1      W=    5.40u L=1.0u
MP6661   #2891    #2839    1      1      MP1      W=    5.40u L=1.0u
MP6660   #2890    #2838    1      1      MP1      W=    5.40u L=1.0u
MP6659   #2889    #2837    1      1      MP1      W=    5.40u L=1.0u
MP6658   #2888    #2836    1      1      MP1      W=    5.40u L=1.0u
MP6657   #2887    #2835    1      1      MP1      W=    5.40u L=1.0u
MP6656   #2886    #2834    1      1      MP1      W=    5.40u L=1.0u
MN6655   #2884    #2847    0      0      MN1      W=    5.40u L=1.0u
MN6654   #2883    #2846    0      0      MN1      W=    5.40u L=1.0u
MN6653   #2882    #2845    0      0      MN1      W=    5.40u L=1.0u
MN6652   #2881    #2844    0      0      MN1      W=    5.40u L=1.0u
MN6651   #2880    #2843    0      0      MN1      W=    5.40u L=1.0u
MN6650   #2879    #2842    0      0      MN1      W=    5.40u L=1.0u
MN6649   #2878    #2841    0      0      MN1      W=    5.40u L=1.0u
MN6648   #2877    #2840    0      0      MN1      W=    5.40u L=1.0u
MN6647   #2876    #2839    0      0      MN1      W=    5.40u L=1.0u
MN6646   #2875    #2838    0      0      MN1      W=    5.40u L=1.0u
MN6645   #2874    #2837    0      0      MN1      W=    5.40u L=1.0u
MN6644   #2873    #2836    0      0      MN1      W=    5.40u L=1.0u
MN6643   #2872    #2835    0      0      MN1      W=    5.40u L=1.0u
MN6642   #2871    #2834    0      0      MN1      W=    5.40u L=1.0u
MP6641   1      X1       #2901    1      MP1      W=   10.80u L=1.0u
MN6640   #2870    #2833    0      0      MN1      W=    5.40u L=1.0u
MN6639   #2869    X1       #2612    0      MN1      W=    3.60u L=1.0u
MN6638   #2406    #2828    0      0      MN1      W=    1.80u L=1.0u
MP6637   #2850    #2828    1      1      MP1      W=    5.40u L=1.0u
MP6636   #2867    #2790    1      1      MP1      W=    5.40u L=1.0u
MN6635   #2868    #2790    #2867    0      MN1      W=    5.40u L=1.0u
MP6634   #2788    #2603    #2899    1      MP1      W=    5.40u L=1.0u
MP6633   #2865    #2610    #2898    1      MP1      W=    5.40u L=1.0u
MP6632   #2864    #2602    #2897    1      MP1      W=    5.40u L=1.0u
MP6631   #2863    #2609    #2896    1      MP1      W=    5.40u L=1.0u
MP6630   #2862    #2601    #2895    1      MP1      W=    5.40u L=1.0u
MP6629   #2861    #2608    #2894    1      MP1      W=    5.40u L=1.0u
MP6628   #2860    #2600    #2893    1      MP1      W=    5.40u L=1.0u
MP6627   #2859    #2607    #2892    1      MP1      W=    5.40u L=1.0u
MP6626   #2858    #2599    #2891    1      MP1      W=    5.40u L=1.0u
MP6625   #2857    #2606    #2890    1      MP1      W=    5.40u L=1.0u
MP6624   #2856    #2598    #2889    1      MP1      W=    5.40u L=1.0u
MP6623   #2855    #2605    #2888    1      MP1      W=    5.40u L=1.0u
MP6622   #2854    #2597    #2887    1      MP1      W=    5.40u L=1.0u
MP6621   #2853    #2699    #2886    1      MP1      W=    5.40u L=1.0u
MP6620   #2852    #2701    #2885    1      MP1      W=    5.40u L=1.0u
MN6619   #2788    #2603    #2884    0      MN1      W=    5.40u L=1.0u
MN6618   #2865    #2610    #2883    0      MN1      W=    5.40u L=1.0u
MN6617   #2864    #2602    #2882    0      MN1      W=    5.40u L=1.0u
MN6616   #2863    #2609    #2881    0      MN1      W=    5.40u L=1.0u
MN6615   #2862    #2601    #2880    0      MN1      W=    5.40u L=1.0u
MN6614   #2861    #2608    #2879    0      MN1      W=    5.40u L=1.0u
MN6613   #2860    #2600    #2878    0      MN1      W=    5.40u L=1.0u
MN6612   #2859    #2607    #2877    0      MN1      W=    5.40u L=1.0u
MN6611   #2858    #2599    #2876    0      MN1      W=    5.40u L=1.0u
MN6610   #2857    #2606    #2875    0      MN1      W=    5.40u L=1.0u
MN6609   #2856    #2598    #2874    0      MN1      W=    5.40u L=1.0u
MN6608   #2855    #2605    #2873    0      MN1      W=    5.40u L=1.0u
MN6607   #2854    #2597    #2872    0      MN1      W=    5.40u L=1.0u
MN6606   #2853    #2699    #2871    0      MN1      W=    5.40u L=1.0u
MN6605   #2852    #2701    #2870    0      MN1      W=    5.40u L=1.0u
MP6604   #2832    X3       1      1      MP1      W=   10.80u L=1.0u
MN6603   0      #2848    #2868    0      MN1      W=    5.40u L=1.0u
MP6602   #2406    #2866    #2850    1      MP1      W=    5.40u L=1.0u
MP6601   1      #2848    #2867    1      MP1      W=    5.40u L=1.0u
MN6600   #2851    #2866    #2406    0      MN1      W=    5.40u L=1.0u
MP6599   #2822    #2865    #2788    1      MP1      W=    5.40u L=1.0u
MP6598   #2821    #2864    #2865    1      MP1      W=    5.40u L=1.0u
MP6597   #2820    #2863    #2864    1      MP1      W=    5.40u L=1.0u
MP6596   #2819    #2862    #2863    1      MP1      W=    5.40u L=1.0u
MP6595   #2818    #2861    #2862    1      MP1      W=    5.40u L=1.0u
MP6594   #2817    #2860    #2861    1      MP1      W=    5.40u L=1.0u
MP6593   #2816    #2859    #2860    1      MP1      W=    5.40u L=1.0u
MP6592   #2815    #2858    #2859    1      MP1      W=    5.40u L=1.0u
MP6591   #2814    #2857    #2858    1      MP1      W=    5.40u L=1.0u
MP6590   #2813    #2856    #2857    1      MP1      W=    5.40u L=1.0u
MP6589   #2812    #2855    #2856    1      MP1      W=    5.40u L=1.0u
MP6588   #2811    #2854    #2855    1      MP1      W=    5.40u L=1.0u
MP6587   #2810    #2853    #2854    1      MP1      W=    5.40u L=1.0u
MP6586   #2809    #2852    #2853    1      MP1      W=    5.40u L=1.0u
MP6585   #2808    #2700    #2852    1      MP1      W=    5.40u L=1.0u
MN6584   #2807    #2865    #2788    0      MN1      W=    5.40u L=1.0u
MN6583   #2806    #2864    #2865    0      MN1      W=    5.40u L=1.0u
MN6582   #2805    #2863    #2864    0      MN1      W=    5.40u L=1.0u
MN6581   #2804    #2862    #2863    0      MN1      W=    5.40u L=1.0u
MN6580   #2803    #2861    #2862    0      MN1      W=    5.40u L=1.0u
MN6579   #2802    #2860    #2861    0      MN1      W=    5.40u L=1.0u
MN6578   #2801    #2859    #2860    0      MN1      W=    5.40u L=1.0u
MN6577   #2800    #2858    #2859    0      MN1      W=    5.40u L=1.0u
MN6576   #2799    #2857    #2858    0      MN1      W=    5.40u L=1.0u
MN6575   #2798    #2856    #2857    0      MN1      W=    5.40u L=1.0u
MN6574   #2797    #2855    #2856    0      MN1      W=    5.40u L=1.0u
MN6573   #2796    #2854    #2855    0      MN1      W=    5.40u L=1.0u
MN6572   #2795    #2853    #2854    0      MN1      W=    5.40u L=1.0u
MN6571   #2794    #2852    #2853    0      MN1      W=    5.40u L=1.0u
MN6570   #2793    #2700    #2852    0      MN1      W=    5.40u L=1.0u
MP6569   1      X2       #2832    1      MP1      W=   10.80u L=1.0u
MN6568   #2849    X2       #2832    0      MN1      W=    3.60u L=1.0u
MN6567   #2848    #2830    0      0      MN1      W=    5.40u L=1.0u
MN6566   0      #2791    #2851    0      MN1      W=    5.40u L=1.0u
MP6565   #2850    #2791    #2406    1      MP1      W=    1.80u L=1.0u
MP6564   #2848    #2830    1      1      MP1      W=    5.40u L=1.0u
MN6563   0      #2847    #2807    0      MN1      W=   16.20u L=1.0u
MP6562   1      #2847    #2822    1      MP1      W=   16.20u L=1.0u
MP6561   1      #2846    #2821    1      MP1      W=   16.20u L=1.0u
MN6560   0      #2846    #2806    0      MN1      W=   16.20u L=1.0u
MN6559   0      #2845    #2805    0      MN1      W=   16.20u L=1.0u
MP6558   1      #2845    #2820    1      MP1      W=   16.20u L=1.0u
MP6557   1      #2844    #2819    1      MP1      W=   16.20u L=1.0u
MN6556   0      #2844    #2804    0      MN1      W=   16.20u L=1.0u
MN6555   0      #2843    #2803    0      MN1      W=   16.20u L=1.0u
MP6554   1      #2843    #2818    1      MP1      W=   16.20u L=1.0u
MP6553   1      #2842    #2817    1      MP1      W=   16.20u L=1.0u
MN6552   0      #2842    #2802    0      MN1      W=   16.20u L=1.0u
MN6551   0      #2841    #2801    0      MN1      W=   16.20u L=1.0u
MP6550   1      #2841    #2816    1      MP1      W=   16.20u L=1.0u
MP6549   1      #2840    #2815    1      MP1      W=   16.20u L=1.0u
MN6548   0      #2840    #2800    0      MN1      W=   16.20u L=1.0u
MN6547   0      #2839    #2799    0      MN1      W=   16.20u L=1.0u
MP6546   1      #2839    #2814    1      MP1      W=   16.20u L=1.0u
MP6545   1      #2838    #2813    1      MP1      W=   16.20u L=1.0u
MN6544   0      #2838    #2798    0      MN1      W=   16.20u L=1.0u
MN6543   0      #2837    #2797    0      MN1      W=   16.20u L=1.0u
MP6542   1      #2837    #2812    1      MP1      W=   16.20u L=1.0u
MP6541   1      #2836    #2811    1      MP1      W=   16.20u L=1.0u
MN6540   0      #2836    #2796    0      MN1      W=   16.20u L=1.0u
MN6539   0      #2835    #2795    0      MN1      W=   16.20u L=1.0u
MP6538   1      #2835    #2810    1      MP1      W=   16.20u L=1.0u
MP6537   1      #2834    #2809    1      MP1      W=   16.20u L=1.0u
MN6536   0      #2834    #2794    0      MN1      W=   16.20u L=1.0u
MN6535   0      #2833    #2793    0      MN1      W=   16.20u L=1.0u
MP6534   1      #2833    #2808    1      MP1      W=   16.20u L=1.0u
MN6533   0      X3       #2849    0      MN1      W=    3.60u L=1.0u
MN6502   #2828    #2830    0      0      MN1      W=    5.40u L=1.0u
MN6501   #2830    #2788    0      0      MN1      W=    5.40u L=1.0u
MP6500   #2831    #2788    #2830    1      MP1      W=    5.40u L=1.0u
MP6484   1      #2832    #2681    1      MP1      W=   10.80u L=1.0u
MP6483   #2829    #2830    #2828    1      MP1      W=    5.40u L=1.0u
MN6467   #2827    #2832    0      0      MN1      W=    3.60u L=1.0u
MP6466   1      #2611    #2831    1      MP1      W=    5.40u L=1.0u
MN6465   0      #2611    #2830    0      MN1      W=    5.40u L=1.0u
MP6464   1      #2604    #2829    1      MP1      W=    5.40u L=1.0u
MN6463   0      #2604    #2828    0      MN1      W=    5.40u L=1.0u
MN6462   #2789    #2612    #2827    0      MN1      W=    3.60u L=1.0u
MP6461   #2681    #2612    1      1      MP1      W=   10.80u L=1.0u
MN6460   #2823    #2611    0      0      MN1      W=    5.40u L=1.0u
MN6459   #2807    #2603    0      0      MN1      W=   10.80u L=1.0u
MN6458   #2806    #2610    0      0      MN1      W=   10.80u L=1.0u
MN6457   #2805    #2602    0      0      MN1      W=   10.80u L=1.0u
MN6456   #2804    #2609    0      0      MN1      W=   10.80u L=1.0u
MN6455   #2803    #2601    0      0      MN1      W=   10.80u L=1.0u
MN6454   #2802    #2608    0      0      MN1      W=   10.80u L=1.0u
MN6453   #2801    #2600    0      0      MN1      W=   10.80u L=1.0u
MN6452   #2800    #2607    0      0      MN1      W=   10.80u L=1.0u
MN6451   #2799    #2599    0      0      MN1      W=   10.80u L=1.0u
MN6450   #2798    #2606    0      0      MN1      W=   10.80u L=1.0u
MN6449   #2797    #2598    0      0      MN1      W=   10.80u L=1.0u
MN6448   #2796    #2605    0      0      MN1      W=   10.80u L=1.0u
MN6447   #2795    #2597    0      0      MN1      W=   10.80u L=1.0u
MN6446   #2794    #2699    0      0      MN1      W=   10.80u L=1.0u
MN6445   #2793    #2701    0      0      MN1      W=   10.80u L=1.0u
MP6444   #2790    #2611    1      1      MP1      W=    5.40u L=1.0u
MP6443   #2822    #2603    1      1      MP1      W=   10.80u L=1.0u
MP6442   #2821    #2610    1      1      MP1      W=   10.80u L=1.0u
MP6441   #2820    #2602    1      1      MP1      W=   10.80u L=1.0u
MP6440   #2819    #2609    1      1      MP1      W=   10.80u L=1.0u
MP6439   #2818    #2601    1      1      MP1      W=   10.80u L=1.0u
MP6438   #2817    #2608    1      1      MP1      W=   10.80u L=1.0u
MP6437   #2816    #2600    1      1      MP1      W=   10.80u L=1.0u
MP6436   #2815    #2607    1      1      MP1      W=   10.80u L=1.0u
MP6435   #2814    #2599    1      1      MP1      W=   10.80u L=1.0u
MP6434   #2813    #2606    1      1      MP1      W=   10.80u L=1.0u
MP6433   #2812    #2598    1      1      MP1      W=   10.80u L=1.0u
MP6432   #2811    #2605    1      1      MP1      W=   10.80u L=1.0u
MP6431   #2810    #2597    1      1      MP1      W=   10.80u L=1.0u
MP6430   #2809    #2699    1      1      MP1      W=   10.80u L=1.0u
MP6429   #2808    #2701    1      1      MP1      W=   10.80u L=1.0u
MP6428   #2791    #2790    1      1      MP1      W=    5.40u L=1.0u
MN6427   #2825    #2790    0      0      MN1      W=    5.40u L=1.0u
MN6426   #2681    X2       #2789    0      MN1      W=    3.60u L=1.0u
MP6425   #2824    X2       #2681    1      MP1      W=   10.80u L=1.0u
MN6424   #2791    #2604    #2825    0      MN1      W=    5.40u L=1.0u
MP6423   1      #2604    #2791    1      MP1      W=    5.40u L=1.0u
MN6422   #2790    #2788    #2823    0      MN1      W=    5.40u L=1.0u
MP6421   1      X3       #2824    1      MP1      W=   10.80u L=1.0u
MP6420   1      #2788    #2790    1      MP1      W=    5.40u L=1.0u
MN6389   #2789    X3       #2681    0      MN1      W=    3.60u L=1.0u
MN6388   0      #2646    #2718    0      MN1      W=    3.60u L=1.0u
MN6387   0      #2647    #2709    0      MN1      W=    3.60u L=1.0u
MN6386   0      #2662    #2717    0      MN1      W=    3.60u L=1.0u
MN6385   0      #2661    #2708    0      MN1      W=    3.60u L=1.0u
MN6384   0      #2660    #2716    0      MN1      W=    3.60u L=1.0u
MN6383   0      #2659    #2707    0      MN1      W=    3.60u L=1.0u
MN6382   0      #2658    #2715    0      MN1      W=    3.60u L=1.0u
MN6381   0      #2657    #2706    0      MN1      W=    3.60u L=1.0u
MN6380   0      #2656    #2714    0      MN1      W=    3.60u L=1.0u
MN6379   0      #2655    #2705    0      MN1      W=    3.60u L=1.0u
MN6378   0      #2654    #2713    0      MN1      W=    3.60u L=1.0u
MN6377   0      #2653    #2704    0      MN1      W=    3.60u L=1.0u
MN6376   0      #2652    #2712    0      MN1      W=    3.60u L=1.0u
MN6375   0      #2651    #2703    0      MN1      W=    3.60u L=1.0u
MN6374   0      #2650    #2711    0      MN1      W=    3.60u L=1.0u
MP6373   1      #2646    #2718    1      MP1      W=    3.60u L=1.0u
MP6372   1      #2647    #2709    1      MP1      W=    3.60u L=1.0u
MP6371   1      #2662    #2717    1      MP1      W=    3.60u L=1.0u
MP6370   1      #2661    #2708    1      MP1      W=    3.60u L=1.0u
MP6369   1      #2660    #2716    1      MP1      W=    3.60u L=1.0u
MP6368   1      #2659    #2707    1      MP1      W=    3.60u L=1.0u
MP6367   1      #2658    #2715    1      MP1      W=    3.60u L=1.0u
MP6366   1      #2657    #2706    1      MP1      W=    3.60u L=1.0u
MP6365   1      #2656    #2714    1      MP1      W=    3.60u L=1.0u
MP6364   1      #2655    #2705    1      MP1      W=    3.60u L=1.0u
MP6363   1      #2654    #2713    1      MP1      W=    3.60u L=1.0u
MP6362   1      #2653    #2704    1      MP1      W=    3.60u L=1.0u
MP6361   1      #2652    #2712    1      MP1      W=    3.60u L=1.0u
MP6360   1      #2651    #2703    1      MP1      W=    3.60u L=1.0u
MP6359   1      #2650    #2711    1      MP1      W=    3.60u L=1.0u
MP6358   1      #2649    #2702    1      MP1      W=    3.60u L=1.0u
MN6357   0      #2649    #2702    0      MN1      W=    3.60u L=1.0u
MP6356   1      #2663    #2710    1      MP1      W=    3.60u L=1.0u
MP6355   #2753    #2701    1      1      MP1      W=   21.60u L=1.0u
MN6354   0      #2663    #2710    0      MN1      W=    3.60u L=1.0u
MN6353   #2753    #2701    0      0      MN1      W=    7.20u L=1.0u
MP6350   #2787    #2718    1      1      MP1      W=    3.60u L=1.0u
MP6349   #2786    #2709    1      1      MP1      W=    3.60u L=1.0u
MP6348   #2785    #2662    1      1      MP1      W=    3.60u L=1.0u
MP6347   #2784    #2708    1      1      MP1      W=    3.60u L=1.0u
MP6346   #2783    #2660    1      1      MP1      W=    3.60u L=1.0u
MP6345   #2782    #2707    1      1      MP1      W=    3.60u L=1.0u
MP6344   #2781    #2658    1      1      MP1      W=    3.60u L=1.0u
MP6343   #2780    #2706    1      1      MP1      W=    3.60u L=1.0u
MP6342   #2779    #2656    1      1      MP1      W=    3.60u L=1.0u
MP6341   #2778    #2705    1      1      MP1      W=    3.60u L=1.0u
MP6340   #2777    #2654    1      1      MP1      W=    3.60u L=1.0u
MP6339   #2776    #2704    1      1      MP1      W=    3.60u L=1.0u
MP6338   #2775    #2652    1      1      MP1      W=    3.60u L=1.0u
MP6337   #2774    #2703    1      1      MP1      W=    3.60u L=1.0u
MP6336   #2773    #2650    1      1      MP1      W=    3.60u L=1.0u
MP6335   #2772    #2702    1      1      MP1      W=    3.60u L=1.0u
MP6334   #2771    #2663    1      1      MP1      W=    3.60u L=1.0u
MN6333   #2770    #2646    0      0      MN1      W=    3.60u L=1.0u
MN6332   #2769    #2647    0      0      MN1      W=    3.60u L=1.0u
MN6331   #2768    #2717    0      0      MN1      W=    3.60u L=1.0u
MN6330   #2767    #2661    0      0      MN1      W=    3.60u L=1.0u
MN6329   #2766    #2716    0      0      MN1      W=    3.60u L=1.0u
MN6328   #2765    #2659    0      0      MN1      W=    3.60u L=1.0u
MN6327   #2764    #2715    0      0      MN1      W=    3.60u L=1.0u
MN6326   #2763    #2657    0      0      MN1      W=    3.60u L=1.0u
MN6325   #2762    #2714    0      0      MN1      W=    3.60u L=1.0u
MN6324   #2761    #2655    0      0      MN1      W=    3.60u L=1.0u
MN6323   #2760    #2713    0      0      MN1      W=    3.60u L=1.0u
MN6322   #2759    #2653    0      0      MN1      W=    3.60u L=1.0u
MN6321   #2758    #2712    0      0      MN1      W=    3.60u L=1.0u
MN6320   #2757    #2651    0      0      MN1      W=    3.60u L=1.0u
MN6319   #2756    #2711    0      0      MN1      W=    3.60u L=1.0u
MN6318   #2755    #2649    0      0      MN1      W=    3.60u L=1.0u
MN6317   #2754    #2710    0      0      MN1      W=    3.60u L=1.0u
MP6316   #2697    #2753    #2787    1      MP1      W=    3.60u L=1.0u
MP6315   #2696    #2753    #2786    1      MP1      W=    3.60u L=1.0u
MP6314   #2695    #2753    #2785    1      MP1      W=    3.60u L=1.0u
MP6313   #2694    #2753    #2784    1      MP1      W=    3.60u L=1.0u
MP6312   #2693    #2753    #2783    1      MP1      W=    3.60u L=1.0u
MP6311   #2692    #2753    #2782    1      MP1      W=    3.60u L=1.0u
MP6310   #2691    #2753    #2781    1      MP1      W=    3.60u L=1.0u
MP6309   #2690    #2753    #2780    1      MP1      W=    3.60u L=1.0u
MP6308   #2689    #2753    #2779    1      MP1      W=    3.60u L=1.0u
MP6307   #2688    #2753    #2778    1      MP1      W=    3.60u L=1.0u
MP6306   #2687    #2753    #2777    1      MP1      W=    3.60u L=1.0u
MP6305   #2686    #2753    #2776    1      MP1      W=    3.60u L=1.0u
MP6304   #2685    #2753    #2775    1      MP1      W=    3.60u L=1.0u
MP6303   #2684    #2753    #2774    1      MP1      W=    3.60u L=1.0u
MP6302   #2683    #2753    #2773    1      MP1      W=    3.60u L=1.0u
MP6301   #2682    #2753    #2772    1      MP1      W=    3.60u L=1.0u
MN6300   #2697    #2753    #2770    0      MN1      W=    3.60u L=1.0u
MN6299   #2696    #2753    #2769    0      MN1      W=    3.60u L=1.0u
MN6298   #2695    #2753    #2768    0      MN1      W=    3.60u L=1.0u
MN6297   #2694    #2753    #2767    0      MN1      W=    3.60u L=1.0u
MN6296   #2693    #2753    #2766    0      MN1      W=    3.60u L=1.0u
MN6295   #2692    #2753    #2765    0      MN1      W=    3.60u L=1.0u
MN6294   #2691    #2753    #2764    0      MN1      W=    3.60u L=1.0u
MN6293   #2690    #2753    #2763    0      MN1      W=    3.60u L=1.0u
MN6292   #2689    #2753    #2762    0      MN1      W=    3.60u L=1.0u
MN6291   #2688    #2753    #2761    0      MN1      W=    3.60u L=1.0u
MN6290   #2687    #2753    #2760    0      MN1      W=    3.60u L=1.0u
MN6289   #2686    #2753    #2759    0      MN1      W=    3.60u L=1.0u
MN6288   #2685    #2753    #2758    0      MN1      W=    3.60u L=1.0u
MN6287   #2684    #2753    #2757    0      MN1      W=    3.60u L=1.0u
MN6286   #2683    #2753    #2756    0      MN1      W=    3.60u L=1.0u
MN6285   #2682    #2753    #2755    0      MN1      W=    3.60u L=1.0u
MP6284   #2698    #2753    #2771    1      MP1      W=    3.60u L=1.0u
MN6283   #2698    #2753    #2754    0      MN1      W=    3.60u L=1.0u
MP6282   #2701    X3       1      1      MP1      W=   21.60u L=1.0u
MN6281   #2701    X3       0      0      MN1      W=    7.20u L=1.0u
MN6280   #2735    #2701    #2697    0      MN1      W=    3.60u L=1.0u
MP6279   #2752    #2701    #2697    1      MP1      W=    3.60u L=1.0u
MP6278   #2750    #2701    #2696    1      MP1      W=    3.60u L=1.0u
MN6277   #2733    #2701    #2695    0      MN1      W=    3.60u L=1.0u
MP6276   #2749    #2701    #2695    1      MP1      W=    3.60u L=1.0u
MP6275   #2748    #2701    #2694    1      MP1      W=    3.60u L=1.0u
MN6274   #2731    #2701    #2693    0      MN1      W=    3.60u L=1.0u
MP6273   #2747    #2701    #2693    1      MP1      W=    3.60u L=1.0u
MP6272   #2746    #2701    #2692    1      MP1      W=    3.60u L=1.0u
MN6271   #2729    #2701    #2691    0      MN1      W=    3.60u L=1.0u
MP6270   #2745    #2701    #2691    1      MP1      W=    3.60u L=1.0u
MP6269   #2744    #2701    #2690    1      MP1      W=    3.60u L=1.0u
MN6268   #2727    #2701    #2689    0      MN1      W=    3.60u L=1.0u
MP6267   #2743    #2701    #2689    1      MP1      W=    3.60u L=1.0u
MP6266   #2742    #2701    #2688    1      MP1      W=    3.60u L=1.0u
MN6265   #2725    #2701    #2687    0      MN1      W=    3.60u L=1.0u
MP6264   #2741    #2701    #2687    1      MP1      W=    3.60u L=1.0u
MP6263   #2740    #2701    #2686    1      MP1      W=    3.60u L=1.0u
MN6262   #2723    #2701    #2685    0      MN1      W=    3.60u L=1.0u
MP6261   #2739    #2701    #2685    1      MP1      W=    3.60u L=1.0u
MP6260   #2738    #2701    #2684    1      MP1      W=    3.60u L=1.0u
MN6259   #2721    #2701    #2683    0      MN1      W=    3.60u L=1.0u
MP6258   #2737    #2701    #2683    1      MP1      W=    3.60u L=1.0u
MP6257   #2736    #2701    #2682    1      MP1      W=    3.60u L=1.0u
MN6256   #2720    #2701    #2682    0      MN1      W=    3.60u L=1.0u
MN6255   #2734    #2701    #2696    0      MN1      W=    3.60u L=1.0u
MN6254   #2732    #2701    #2694    0      MN1      W=    3.60u L=1.0u
MN6253   #2730    #2701    #2692    0      MN1      W=    3.60u L=1.0u
MN6252   #2728    #2701    #2690    0      MN1      W=    3.60u L=1.0u
MN6251   #2726    #2701    #2688    0      MN1      W=    3.60u L=1.0u
MN6250   #2724    #2701    #2686    0      MN1      W=    3.60u L=1.0u
MN6249   #2722    #2701    #2684    0      MN1      W=    3.60u L=1.0u
MN6248   #2719    #2701    #2698    0      MN1      W=    3.60u L=1.0u
MP6247   #2751    #2701    #2698    1      MP1      W=    3.60u L=1.0u
MP6244   1      #2646    #2752    1      MP1      W=    3.60u L=1.0u
MP6243   1      #2710    #2751    1      MP1      W=    3.60u L=1.0u
MN6242   0      #2718    #2735    0      MN1      W=    3.60u L=1.0u
MP6241   1      #2647    #2750    1      MP1      W=    3.60u L=1.0u
MN6240   0      #2709    #2734    0      MN1      W=    3.60u L=1.0u
MN6239   0      #2662    #2733    0      MN1      W=    3.60u L=1.0u
MP6238   1      #2717    #2749    1      MP1      W=    3.60u L=1.0u
MP6237   1      #2661    #2748    1      MP1      W=    3.60u L=1.0u
MN6236   0      #2708    #2732    0      MN1      W=    3.60u L=1.0u
MN6235   0      #2660    #2731    0      MN1      W=    3.60u L=1.0u
MP6234   1      #2716    #2747    1      MP1      W=    3.60u L=1.0u
MP6233   1      #2659    #2746    1      MP1      W=    3.60u L=1.0u
MN6232   0      #2707    #2730    0      MN1      W=    3.60u L=1.0u
MN6231   0      #2658    #2729    0      MN1      W=    3.60u L=1.0u
MP6230   1      #2715    #2745    1      MP1      W=    3.60u L=1.0u
MP6229   1      #2657    #2744    1      MP1      W=    3.60u L=1.0u
MN6228   0      #2706    #2728    0      MN1      W=    3.60u L=1.0u
MN6227   0      #2656    #2727    0      MN1      W=    3.60u L=1.0u
MP6226   1      #2714    #2743    1      MP1      W=    3.60u L=1.0u
MP6225   1      #2655    #2742    1      MP1      W=    3.60u L=1.0u
MN6224   0      #2705    #2726    0      MN1      W=    3.60u L=1.0u
MN6223   0      #2654    #2725    0      MN1      W=    3.60u L=1.0u
MP6222   1      #2713    #2741    1      MP1      W=    3.60u L=1.0u
MP6221   1      #2653    #2740    1      MP1      W=    3.60u L=1.0u
MN6220   0      #2704    #2724    0      MN1      W=    3.60u L=1.0u
MN6219   0      #2652    #2723    0      MN1      W=    3.60u L=1.0u
MP6218   1      #2712    #2739    1      MP1      W=    3.60u L=1.0u
MP6217   1      #2651    #2738    1      MP1      W=    3.60u L=1.0u
MN6216   0      #2703    #2722    0      MN1      W=    3.60u L=1.0u
MN6215   0      #2650    #2721    0      MN1      W=    3.60u L=1.0u
MP6214   1      #2711    #2737    1      MP1      W=    3.60u L=1.0u
MP6213   1      #2649    #2736    1      MP1      W=    3.60u L=1.0u
MN6212   0      #2702    #2720    0      MN1      W=    3.60u L=1.0u
MN6211   0      #2663    #2719    0      MN1      W=    3.60u L=1.0u
MN6210   #2648    #2681    0      0      MN1      W=   14.40u L=1.0u
MP6209   #2648    #2681    1      1      MP1      W=   43.20u L=1.0u
MP6208   #2700    #2698    1      1      MP1      W=   10.80u L=1.0u
MN6207   #2422    #2697    0      0      MN1      W=   10.80u L=1.0u
MN6206   #2421    #2696    0      0      MN1      W=   10.80u L=1.0u
MN6205   #2420    #2695    0      0      MN1      W=   10.80u L=1.0u
MN6204   #2419    #2694    0      0      MN1      W=   10.80u L=1.0u
MN6203   #2418    #2693    0      0      MN1      W=   10.80u L=1.0u
MN6202   #2417    #2692    0      0      MN1      W=   10.80u L=1.0u
MN6201   #2416    #2691    0      0      MN1      W=   10.80u L=1.0u
MN6200   #2415    #2690    0      0      MN1      W=   10.80u L=1.0u
MN6199   #2414    #2689    0      0      MN1      W=   10.80u L=1.0u
MN6198   #2413    #2688    0      0      MN1      W=   10.80u L=1.0u
MN6197   #2412    #2687    0      0      MN1      W=   10.80u L=1.0u
MN6196   #2411    #2686    0      0      MN1      W=   10.80u L=1.0u
MN6195   #2410    #2685    0      0      MN1      W=   10.80u L=1.0u
MN6194   #2409    #2684    0      0      MN1      W=   10.80u L=1.0u
MN6193   #2408    #2683    0      0      MN1      W=   10.80u L=1.0u
MN6192   #2699    #2682    0      0      MN1      W=   10.80u L=1.0u
MN6191   #2700    #2698    0      0      MN1      W=   10.80u L=1.0u
MP6190   #2422    #2697    1      1      MP1      W=   10.80u L=1.0u
MP6189   #2421    #2696    1      1      MP1      W=   10.80u L=1.0u
MP6188   #2420    #2695    1      1      MP1      W=   10.80u L=1.0u
MP6187   #2419    #2694    1      1      MP1      W=   10.80u L=1.0u
MP6186   #2418    #2693    1      1      MP1      W=   10.80u L=1.0u
MP6185   #2417    #2692    1      1      MP1      W=   10.80u L=1.0u
MP6184   #2416    #2691    1      1      MP1      W=   10.80u L=1.0u
MP6183   #2415    #2690    1      1      MP1      W=   10.80u L=1.0u
MP6182   #2414    #2689    1      1      MP1      W=   10.80u L=1.0u
MP6181   #2413    #2688    1      1      MP1      W=   10.80u L=1.0u
MP6180   #2412    #2687    1      1      MP1      W=   10.80u L=1.0u
MP6179   #2411    #2686    1      1      MP1      W=   10.80u L=1.0u
MP6178   #2410    #2685    1      1      MP1      W=   10.80u L=1.0u
MP6177   #2409    #2684    1      1      MP1      W=   10.80u L=1.0u
MP6176   #2408    #2683    1      1      MP1      W=   10.80u L=1.0u
MP6175   #2699    #2682    1      1      MP1      W=   10.80u L=1.0u
MP6136   #2630    #2648    1      1      MP1      W=    3.60u L=1.0u
MP6135   #2629    #2648    1      1      MP1      W=    3.60u L=1.0u
MP6134   #2628    #2648    1      1      MP1      W=    3.60u L=1.0u
MP6133   #2627    #2648    1      1      MP1      W=    3.60u L=1.0u
MP6132   #2626    #2648    1      1      MP1      W=    3.60u L=1.0u
MP6131   #2625    #2648    1      1      MP1      W=    3.60u L=1.0u
MP6130   #2624    #2648    1      1      MP1      W=    3.60u L=1.0u
MP6129   #2623    #2648    1      1      MP1      W=    3.60u L=1.0u
MP6128   #2622    #2648    1      1      MP1      W=    3.60u L=1.0u
MP6127   #2621    #2648    1      1      MP1      W=    3.60u L=1.0u
MP6126   #2620    #2648    1      1      MP1      W=    3.60u L=1.0u
MP6125   #2619    #2648    1      1      MP1      W=    3.60u L=1.0u
MP6124   #2618    #2648    1      1      MP1      W=    3.60u L=1.0u
MP6123   #2617    #2648    1      1      MP1      W=    3.60u L=1.0u
MP6122   #2663    #2613    1      1      MP1      W=    3.60u L=1.0u
MN6121   #2680    #2613    0      0      MN1      W=    3.60u L=1.0u
MN6120   #2679    #2613    0      0      MN1      W=    3.60u L=1.0u
MN6119   #2678    #2613    0      0      MN1      W=    3.60u L=1.0u
MN6118   #2677    #2613    0      0      MN1      W=    3.60u L=1.0u
MN6117   #2676    #2613    0      0      MN1      W=    3.60u L=1.0u
MN6116   #2675    #2613    0      0      MN1      W=    3.60u L=1.0u
MN6115   #2674    #2613    0      0      MN1      W=    3.60u L=1.0u
MN6114   #2673    #2613    0      0      MN1      W=    3.60u L=1.0u
MN6113   #2672    #2613    0      0      MN1      W=    3.60u L=1.0u
MN6112   #2671    #2613    0      0      MN1      W=    3.60u L=1.0u
MN6111   #2670    #2613    0      0      MN1      W=    3.60u L=1.0u
MN6110   #2669    #2613    0      0      MN1      W=    3.60u L=1.0u
MN6109   #2668    #2613    0      0      MN1      W=    3.60u L=1.0u
MN6108   #2667    #2613    0      0      MN1      W=    3.60u L=1.0u
MN6107   #2666    #2613    0      0      MN1      W=    3.60u L=1.0u
MN6106   #2665    #2613    0      0      MN1      W=    3.60u L=1.0u
MP6105   #2616    #2648    1      1      MP1      W=    3.60u L=1.0u
MP6103   #2614    #2648    1      1      MP1      W=    3.60u L=1.0u
MN6101   #2664    #2613    0      0      MN1      W=    3.60u L=1.0u
MP6100   #2662    #51      #2630    1      MP1      W=    3.60u L=1.0u
MP6099   #2661    #50      #2629    1      MP1      W=    3.60u L=1.0u
MP6098   #2660    #49      #2628    1      MP1      W=    3.60u L=1.0u
MP6097   #2659    #48      #2627    1      MP1      W=    3.60u L=1.0u
MP6096   #2658    #47      #2626    1      MP1      W=    3.60u L=1.0u
MP6095   #2657    #46      #2625    1      MP1      W=    3.60u L=1.0u
MP6094   #2656    #45      #2624    1      MP1      W=    3.60u L=1.0u
MP6093   #2655    #44      #2623    1      MP1      W=    3.60u L=1.0u
MP6092   #2654    #43      #2622    1      MP1      W=    3.60u L=1.0u
MP6091   #2653    #42      #2621    1      MP1      W=    3.60u L=1.0u
MP6090   #2652    #41      #2620    1      MP1      W=    3.60u L=1.0u
MP6089   #2651    #40      #2619    1      MP1      W=    3.60u L=1.0u
MP6088   #2650    #39      #2618    1      MP1      W=    3.60u L=1.0u
MP6087   #2649    #38      #2617    1      MP1      W=    3.60u L=1.0u
MN6086   #2647    #52      #2680    0      MN1      W=    3.60u L=1.0u
MN6085   #2662    #51      #2679    0      MN1      W=    3.60u L=1.0u
MN6084   #2661    #50      #2678    0      MN1      W=    3.60u L=1.0u
MN6083   #2660    #49      #2677    0      MN1      W=    3.60u L=1.0u
MN6082   #2659    #48      #2676    0      MN1      W=    3.60u L=1.0u
MN6081   #2658    #47      #2675    0      MN1      W=    3.60u L=1.0u
MN6080   #2657    #46      #2674    0      MN1      W=    3.60u L=1.0u
MN6079   #2656    #45      #2673    0      MN1      W=    3.60u L=1.0u
MN6078   #2655    #44      #2672    0      MN1      W=    3.60u L=1.0u
MN6077   #2654    #43      #2671    0      MN1      W=    3.60u L=1.0u
MN6076   #2653    #42      #2670    0      MN1      W=    3.60u L=1.0u
MN6075   #2652    #41      #2669    0      MN1      W=    3.60u L=1.0u
MN6074   #2651    #40      #2668    0      MN1      W=    3.60u L=1.0u
MN6073   #2650    #39      #2667    0      MN1      W=    3.60u L=1.0u
MN6072   #2649    #38      #2666    0      MN1      W=    3.60u L=1.0u
MN6071   #2663    #37      #2665    0      MN1      W=    3.60u L=1.0u
MP6070   1      #37      #2663    1      MP1      W=    3.60u L=1.0u
MP6069   #2647    #52      #2616    1      MP1      W=    3.60u L=1.0u
MP6068   #2646    #52      #2614    1      MP1      W=    3.60u L=1.0u
MN6067   #2613    #2612    0      0      MN1      W=   14.40u L=1.0u
MN6066   #2646    #52      #2664    0      MN1      W=    3.60u L=1.0u
MP6065   #2613    #2612    1      1      MP1      W=   43.20u L=1.0u
MN6064   #2645    #2648    #2647    0      MN1      W=    3.60u L=1.0u
MN6063   #2644    #2648    #2662    0      MN1      W=    3.60u L=1.0u
MN6062   #2643    #2648    #2661    0      MN1      W=    3.60u L=1.0u
MN6061   #2642    #2648    #2660    0      MN1      W=    3.60u L=1.0u
MN6060   #2641    #2648    #2659    0      MN1      W=    3.60u L=1.0u
MN6059   #2640    #2648    #2658    0      MN1      W=    3.60u L=1.0u
MN6058   #2639    #2648    #2657    0      MN1      W=    3.60u L=1.0u
MN6057   #2638    #2648    #2656    0      MN1      W=    3.60u L=1.0u
MN6056   #2637    #2648    #2655    0      MN1      W=    3.60u L=1.0u
MN6055   #2636    #2648    #2654    0      MN1      W=    3.60u L=1.0u
MN6054   #2635    #2648    #2653    0      MN1      W=    3.60u L=1.0u
MN6053   #2634    #2648    #2652    0      MN1      W=    3.60u L=1.0u
MN6052   #2633    #2648    #2651    0      MN1      W=    3.60u L=1.0u
MN6051   #2632    #2648    #2650    0      MN1      W=    3.60u L=1.0u
MP6050   #2630    #2613    #2662    1      MP1      W=    3.60u L=1.0u
MP6049   #2629    #2613    #2661    1      MP1      W=    3.60u L=1.0u
MP6048   #2628    #2613    #2660    1      MP1      W=    3.60u L=1.0u
MP6047   #2627    #2613    #2659    1      MP1      W=    3.60u L=1.0u
MP6046   #2626    #2613    #2658    1      MP1      W=    3.60u L=1.0u
MP6045   #2625    #2613    #2657    1      MP1      W=    3.60u L=1.0u
MP6044   #2624    #2613    #2656    1      MP1      W=    3.60u L=1.0u
MP6043   #2623    #2613    #2655    1      MP1      W=    3.60u L=1.0u
MP6042   #2622    #2613    #2654    1      MP1      W=    3.60u L=1.0u
MP6041   #2621    #2613    #2653    1      MP1      W=    3.60u L=1.0u
MP6040   #2620    #2613    #2652    1      MP1      W=    3.60u L=1.0u
MP6039   #2619    #2613    #2651    1      MP1      W=    3.60u L=1.0u
MP6038   #2618    #2613    #2650    1      MP1      W=    3.60u L=1.0u
MP6037   #2617    #2613    #2649    1      MP1      W=    3.60u L=1.0u
MN6036   #2631    #2648    #2649    0      MN1      W=    3.60u L=1.0u
MN6035   #2615    #2648    #2646    0      MN1      W=    3.60u L=1.0u
MP6033   #2616    #2613    #2647    1      MP1      W=    3.60u L=1.0u
MP6031   #2614    #2613    #2646    1      MP1      W=    3.60u L=1.0u
MN6030   0      #51      #2645    0      MN1      W=    3.60u L=1.0u
MN6029   0      #50      #2644    0      MN1      W=    3.60u L=1.0u
MN6028   0      #49      #2643    0      MN1      W=    3.60u L=1.0u
MN6027   0      #48      #2642    0      MN1      W=    3.60u L=1.0u
MN6026   0      #47      #2641    0      MN1      W=    3.60u L=1.0u
MN6025   0      #46      #2640    0      MN1      W=    3.60u L=1.0u
MN6024   0      #45      #2639    0      MN1      W=    3.60u L=1.0u
MN6023   0      #44      #2638    0      MN1      W=    3.60u L=1.0u
MN6022   0      #43      #2637    0      MN1      W=    3.60u L=1.0u
MN6021   0      #42      #2636    0      MN1      W=    3.60u L=1.0u
MN6020   0      #41      #2635    0      MN1      W=    3.60u L=1.0u
MN6019   0      #40      #2634    0      MN1      W=    3.60u L=1.0u
MN6018   0      #39      #2633    0      MN1      W=    3.60u L=1.0u
MN6017   0      #38      #2632    0      MN1      W=    3.60u L=1.0u
MN6016   0      #37      #2631    0      MN1      W=    3.60u L=1.0u
MP6015   1      #50      #2630    1      MP1      W=    3.60u L=1.0u
MP6014   1      #49      #2629    1      MP1      W=    3.60u L=1.0u
MP6013   1      #48      #2628    1      MP1      W=    3.60u L=1.0u
MP6012   1      #47      #2627    1      MP1      W=    3.60u L=1.0u
MP6011   1      #46      #2626    1      MP1      W=    3.60u L=1.0u
MP6010   1      #45      #2625    1      MP1      W=    3.60u L=1.0u
MP6009   1      #44      #2624    1      MP1      W=    3.60u L=1.0u
MP6008   1      #43      #2623    1      MP1      W=    3.60u L=1.0u
MP6007   1      #42      #2622    1      MP1      W=    3.60u L=1.0u
MP6006   1      #41      #2621    1      MP1      W=    3.60u L=1.0u
MP6005   1      #40      #2620    1      MP1      W=    3.60u L=1.0u
MP6004   1      #39      #2619    1      MP1      W=    3.60u L=1.0u
MP6003   1      #38      #2618    1      MP1      W=    3.60u L=1.0u
MP6002   1      #37      #2617    1      MP1      W=    3.60u L=1.0u
MN6001   0      #52      #2615    0      MN1      W=    3.60u L=1.0u
MP6000   1      #51      #2616    1      MP1      W=    3.60u L=1.0u
MP5999   1      #52      #2614    1      MP1      W=    3.60u L=1.0u
MN5996   #2597    #2514    0      0      MN1      W=   10.80u L=1.0u
MP5995   #2597    #2514    1      1      MP1      W=   10.80u L=1.0u
MN5994   #2604    #2521    0      0      MN1      W=   10.80u L=1.0u
MN5993   #2611    #2528    0      0      MN1      W=   10.80u L=1.0u
MN5992   #2603    #2520    0      0      MN1      W=   10.80u L=1.0u
MN5991   #2610    #2527    0      0      MN1      W=   10.80u L=1.0u
MN5990   #2602    #2519    0      0      MN1      W=   10.80u L=1.0u
MN5989   #2609    #2526    0      0      MN1      W=   10.80u L=1.0u
MN5988   #2601    #2518    0      0      MN1      W=   10.80u L=1.0u
MN5987   #2608    #2525    0      0      MN1      W=   10.80u L=1.0u
MN5986   #2600    #2517    0      0      MN1      W=   10.80u L=1.0u
MN5985   #2607    #2524    0      0      MN1      W=   10.80u L=1.0u
MN5984   #2599    #2516    0      0      MN1      W=   10.80u L=1.0u
MN5983   #2606    #2523    0      0      MN1      W=   10.80u L=1.0u
MN5982   #2598    #2515    0      0      MN1      W=   10.80u L=1.0u
MN5981   #2605    #2522    0      0      MN1      W=   10.80u L=1.0u
MP5980   #2604    #2521    1      1      MP1      W=   10.80u L=1.0u
MP5979   #2611    #2528    1      1      MP1      W=   10.80u L=1.0u
MP5978   #2603    #2520    1      1      MP1      W=   10.80u L=1.0u
MP5977   #2610    #2527    1      1      MP1      W=   10.80u L=1.0u
MP5976   #2602    #2519    1      1      MP1      W=   10.80u L=1.0u
MP5975   #2609    #2526    1      1      MP1      W=   10.80u L=1.0u
MP5974   #2601    #2518    1      1      MP1      W=   10.80u L=1.0u
MP5973   #2608    #2525    1      1      MP1      W=   10.80u L=1.0u
MP5972   #2600    #2517    1      1      MP1      W=   10.80u L=1.0u
MP5971   #2607    #2524    1      1      MP1      W=   10.80u L=1.0u
MP5970   #2599    #2516    1      1      MP1      W=   10.80u L=1.0u
MP5969   #2606    #2523    1      1      MP1      W=   10.80u L=1.0u
MP5968   #2598    #2515    1      1      MP1      W=   10.80u L=1.0u
MP5967   #2605    #2522    1      1      MP1      W=   10.80u L=1.0u
MN5941   0      #2477    #2577    0      MN1      W=    1.80u L=1.0u
MN5933   Z19      #2529    0      0      MN1      W=    3.60u L=1.0u
MP5932   Z19      #2529    1      1      MP1      W=    3.60u L=1.0u
MP5931   #2596    #2443    1      1      MP1      W=    1.80u L=1.0u
MN5930   #2562    #2408    0      0      MN1      W=    5.40u L=1.0u
MP5929   #2592    #2408    1      1      MP1      W=    5.40u L=1.0u
MN5928   #2577    #2443    0      0      MN1      W=    1.80u L=1.0u
MP5927   #2594    #2181    1      1      MP1      W=    5.40u L=1.0u
MN5926   #2576    #2422    0      0      MN1      W=    5.40u L=1.0u
MN5925   #2574    #2420    0      0      MN1      W=    5.40u L=1.0u
MN5924   #2572    #2418    0      0      MN1      W=    5.40u L=1.0u
MN5923   #2570    #2416    0      0      MN1      W=    5.40u L=1.0u
MN5922   #2568    #2414    0      0      MN1      W=    5.40u L=1.0u
MN5921   #2566    #2412    0      0      MN1      W=    5.40u L=1.0u
MN5920   #2564    #2410    0      0      MN1      W=    5.40u L=1.0u
MP5919   #2591    #2422    1      1      MP1      W=    5.40u L=1.0u
MP5918   #2589    #2420    1      1      MP1      W=    5.40u L=1.0u
MP5917   #2587    #2418    1      1      MP1      W=    5.40u L=1.0u
MP5916   #2585    #2416    1      1      MP1      W=    5.40u L=1.0u
MP5915   #2583    #2414    1      1      MP1      W=    5.40u L=1.0u
MP5914   #2581    #2412    1      1      MP1      W=    5.40u L=1.0u
MP5913   #2579    #2410    1      1      MP1      W=    5.40u L=1.0u
MN5912   #2593    #2181    0      0      MN1      W=    5.40u L=1.0u
MP5911   #2590    #2421    1      1      MP1      W=    5.40u L=1.0u
MP5910   #2588    #2419    1      1      MP1      W=    5.40u L=1.0u
MP5909   #2586    #2417    1      1      MP1      W=    5.40u L=1.0u
MP5908   #2584    #2415    1      1      MP1      W=    5.40u L=1.0u
MP5907   #2582    #2413    1      1      MP1      W=    5.40u L=1.0u
MP5906   #2580    #2411    1      1      MP1      W=    5.40u L=1.0u
MP5905   #2578    #2409    1      1      MP1      W=    5.40u L=1.0u
MN5904   #2575    #2421    0      0      MN1      W=    5.40u L=1.0u
MN5903   #2573    #2419    0      0      MN1      W=    5.40u L=1.0u
MN5902   #2571    #2417    0      0      MN1      W=    5.40u L=1.0u
MN5901   #2569    #2415    0      0      MN1      W=    5.40u L=1.0u
MN5900   #2567    #2413    0      0      MN1      W=    5.40u L=1.0u
MN5899   #2565    #2411    0      0      MN1      W=    5.40u L=1.0u
MN5898   #2563    #2409    0      0      MN1      W=    5.40u L=1.0u
MP5897   #2529    #2477    #2596    1      MP1      W=    1.80u L=1.0u
MP5896   #2561    #2423    #2594    1      MP1      W=    5.40u L=1.0u
MN5895   #2560    #2423    #2593    0      MN1      W=    5.40u L=1.0u
MP5894   #2559    #2278    #2592    1      MP1      W=    5.40u L=1.0u
MP5893   #2558    #2180    #2591    1      MP1      W=    5.40u L=1.0u
MP5892   #2557    #2187    #2590    1      MP1      W=    5.40u L=1.0u
MP5891   #2556    #2179    #2589    1      MP1      W=    5.40u L=1.0u
MP5890   #2555    #2186    #2588    1      MP1      W=    5.40u L=1.0u
MP5889   #2554    #2178    #2587    1      MP1      W=    5.40u L=1.0u
MP5888   #2553    #2185    #2586    1      MP1      W=    5.40u L=1.0u
MP5887   #2552    #2177    #2585    1      MP1      W=    5.40u L=1.0u
MP5886   #2551    #2184    #2584    1      MP1      W=    5.40u L=1.0u
MP5885   #2550    #2176    #2583    1      MP1      W=    5.40u L=1.0u
MP5884   #2549    #2183    #2582    1      MP1      W=    5.40u L=1.0u
MP5883   #2548    #2175    #2581    1      MP1      W=    5.40u L=1.0u
MP5882   #2547    #2182    #2580    1      MP1      W=    5.40u L=1.0u
MP5881   #2546    #2174    #2579    1      MP1      W=    5.40u L=1.0u
MP5880   #2545    #2276    #2578    1      MP1      W=    5.40u L=1.0u
MN5879   #2529    #2513    #2577    0      MN1      W=    1.80u L=1.0u
MN5878   #2544    #2180    #2576    0      MN1      W=    5.40u L=1.0u
MN5877   #2543    #2187    #2575    0      MN1      W=    5.40u L=1.0u
MN5876   #2542    #2179    #2574    0      MN1      W=    5.40u L=1.0u
MN5875   #2541    #2186    #2573    0      MN1      W=    5.40u L=1.0u
MN5874   #2540    #2178    #2572    0      MN1      W=    5.40u L=1.0u
MN5873   #2539    #2185    #2571    0      MN1      W=    5.40u L=1.0u
MN5872   #2538    #2177    #2570    0      MN1      W=    5.40u L=1.0u
MN5871   #2537    #2184    #2569    0      MN1      W=    5.40u L=1.0u
MN5870   #2536    #2176    #2568    0      MN1      W=    5.40u L=1.0u
MN5869   #2535    #2183    #2567    0      MN1      W=    5.40u L=1.0u
MN5868   #2534    #2175    #2566    0      MN1      W=    5.40u L=1.0u
MN5867   #2533    #2182    #2565    0      MN1      W=    5.40u L=1.0u
MN5866   #2532    #2174    #2564    0      MN1      W=    5.40u L=1.0u
MN5865   #2531    #2276    #2563    0      MN1      W=    5.40u L=1.0u
MN5864   #2530    #2278    #2562    0      MN1      W=    5.40u L=1.0u
MP5863   Z20      #2513    #2561    1      MP1      W=    5.40u L=1.0u
MN5862   Z20      #2513    #2560    0      MN1      W=    5.40u L=1.0u
MP5861   #2514    #2277    #2559    1      MP1      W=    1.80u L=1.0u
MN5860   #2521    #2441    #2544    0      MN1      W=    1.80u L=1.0u
MP5859   #2521    #2441    #2558    1      MP1      W=    1.80u L=1.0u
MP5858   #2528    #2440    #2557    1      MP1      W=    1.80u L=1.0u
MN5857   #2528    #2440    #2543    0      MN1      W=    1.80u L=1.0u
MN5856   #2520    #2439    #2542    0      MN1      W=    1.80u L=1.0u
MP5855   #2520    #2439    #2556    1      MP1      W=    1.80u L=1.0u
MP5854   #2527    #2438    #2555    1      MP1      W=    1.80u L=1.0u
MN5853   #2527    #2438    #2541    0      MN1      W=    1.80u L=1.0u
MN5852   #2519    #2437    #2540    0      MN1      W=    1.80u L=1.0u
MP5851   #2519    #2437    #2554    1      MP1      W=    1.80u L=1.0u
MP5850   #2526    #2436    #2553    1      MP1      W=    1.80u L=1.0u
MN5849   #2526    #2436    #2539    0      MN1      W=    1.80u L=1.0u
MN5848   #2518    #2435    #2538    0      MN1      W=    1.80u L=1.0u
MP5847   #2518    #2435    #2552    1      MP1      W=    1.80u L=1.0u
MP5846   #2525    #2434    #2551    1      MP1      W=    1.80u L=1.0u
MN5845   #2525    #2434    #2537    0      MN1      W=    1.80u L=1.0u
MN5844   #2517    #2433    #2536    0      MN1      W=    1.80u L=1.0u
MP5843   #2517    #2433    #2550    1      MP1      W=    1.80u L=1.0u
MP5842   #2524    #2432    #2549    1      MP1      W=    1.80u L=1.0u
MN5841   #2524    #2432    #2535    0      MN1      W=    1.80u L=1.0u
MN5840   #2516    #2431    #2534    0      MN1      W=    1.80u L=1.0u
MP5839   #2516    #2431    #2548    1      MP1      W=    1.80u L=1.0u
MP5838   #2523    #2430    #2547    1      MP1      W=    1.80u L=1.0u
MN5837   #2523    #2430    #2533    0      MN1      W=    1.80u L=1.0u
MN5836   #2515    #2429    #2532    0      MN1      W=    1.80u L=1.0u
MP5835   #2515    #2429    #2546    1      MP1      W=    1.80u L=1.0u
MP5834   #2522    #2428    #2545    1      MP1      W=    1.80u L=1.0u
MN5833   #2522    #2428    #2531    0      MN1      W=    1.80u L=1.0u
MP5832   1      #2513    #2529    1      MP1      W=    1.80u L=1.0u
MN5831   #2514    #2277    #2530    0      MN1      W=    1.80u L=1.0u
MP5830   #2509    #2018    Z20      1      MP1      W=    1.80u L=1.0u
MN5829   #2508    #2018    Z20      0      MN1      W=    1.80u L=1.0u
MN5828   #2491    #2441    #2528    0      MN1      W=    1.80u L=1.0u
MN5827   #2489    #2439    #2527    0      MN1      W=    1.80u L=1.0u
MN5826   #2487    #2437    #2526    0      MN1      W=    1.80u L=1.0u
MN5825   #2485    #2435    #2525    0      MN1      W=    1.80u L=1.0u
MN5824   #2483    #2433    #2524    0      MN1      W=    1.80u L=1.0u
MN5823   #2481    #2431    #2523    0      MN1      W=    1.80u L=1.0u
MN5822   #2479    #2429    #2522    0      MN1      W=    1.80u L=1.0u
MP5821   #2507    #2428    #2514    1      MP1      W=    1.80u L=1.0u
MP5820   #2506    #2365    #2521    1      MP1      W=    1.80u L=1.0u
MP5819   #2505    #2441    #2528    1      MP1      W=    1.80u L=1.0u
MP5818   #2504    #2440    #2520    1      MP1      W=    1.80u L=1.0u
MP5817   #2503    #2439    #2527    1      MP1      W=    1.80u L=1.0u
MP5816   #2502    #2438    #2519    1      MP1      W=    1.80u L=1.0u
MP5815   #2501    #2437    #2526    1      MP1      W=    1.80u L=1.0u
MP5814   #2500    #2436    #2518    1      MP1      W=    1.80u L=1.0u
MP5813   #2499    #2435    #2525    1      MP1      W=    1.80u L=1.0u
MP5812   #2498    #2434    #2517    1      MP1      W=    1.80u L=1.0u
MP5811   #2497    #2433    #2524    1      MP1      W=    1.80u L=1.0u
MP5810   #2496    #2432    #2516    1      MP1      W=    1.80u L=1.0u
MP5809   #2495    #2431    #2523    1      MP1      W=    1.80u L=1.0u
MP5808   #2494    #2430    #2515    1      MP1      W=    1.80u L=1.0u
MP5807   #2493    #2429    #2522    1      MP1      W=    1.80u L=1.0u
MN5806   #2492    #2365    #2521    0      MN1      W=    1.80u L=1.0u
MN5805   #2490    #2440    #2520    0      MN1      W=    1.80u L=1.0u
MN5804   #2488    #2438    #2519    0      MN1      W=    1.80u L=1.0u
MN5803   #2486    #2436    #2518    0      MN1      W=    1.80u L=1.0u
MN5802   #2484    #2434    #2517    0      MN1      W=    1.80u L=1.0u
MN5801   #2482    #2432    #2516    0      MN1      W=    1.80u L=1.0u
MN5800   #2480    #2430    #2515    0      MN1      W=    1.80u L=1.0u
MN5799   #2478    #2428    #2514    0      MN1      W=    1.80u L=1.0u
MP5798   #2513    #2477    1      1      MP1      W=    1.80u L=1.0u
MP5797   #2510    X3       1      1      MP1      W=   10.80u L=1.0u
MN5796   #2511    X3       #2510    0      MN1      W=    3.60u L=1.0u
MN5795   #2512    #2477    #2513    0      MN1      W=    1.80u L=1.0u
MP5794   1      #2513    #2509    1      MP1      W=    5.40u L=1.0u
MN5793   0      #2513    #2508    0      MN1      W=    5.40u L=1.0u
MN5792   0      #2440    #2491    0      MN1      W=    1.80u L=1.0u
MN5791   0      #2438    #2489    0      MN1      W=    1.80u L=1.0u
MN5790   0      #2436    #2487    0      MN1      W=    1.80u L=1.0u
MN5789   0      #2434    #2485    0      MN1      W=    1.80u L=1.0u
MN5788   0      #2432    #2483    0      MN1      W=    1.80u L=1.0u
MN5787   0      #2430    #2481    0      MN1      W=    1.80u L=1.0u
MN5786   0      #2428    #2479    0      MN1      W=    1.80u L=1.0u
MP5785   1      #2277    #2507    1      MP1      W=    1.80u L=1.0u
MN5784   0      #2441    #2492    0      MN1      W=    1.80u L=1.0u
MP5783   1      #2441    #2506    1      MP1      W=    1.80u L=1.0u
MP5782   1      #2440    #2505    1      MP1      W=    1.80u L=1.0u
MN5781   0      #2439    #2490    0      MN1      W=    1.80u L=1.0u
MP5780   1      #2439    #2504    1      MP1      W=    1.80u L=1.0u
MP5779   1      #2438    #2503    1      MP1      W=    1.80u L=1.0u
MN5778   0      #2437    #2488    0      MN1      W=    1.80u L=1.0u
MP5777   1      #2437    #2502    1      MP1      W=    1.80u L=1.0u
MP5776   1      #2436    #2501    1      MP1      W=    1.80u L=1.0u
MN5775   0      #2435    #2486    0      MN1      W=    1.80u L=1.0u
MP5774   1      #2435    #2500    1      MP1      W=    1.80u L=1.0u
MP5773   1      #2434    #2499    1      MP1      W=    1.80u L=1.0u
MN5772   0      #2433    #2484    0      MN1      W=    1.80u L=1.0u
MP5771   1      #2433    #2498    1      MP1      W=    1.80u L=1.0u
MP5770   1      #2432    #2497    1      MP1      W=    1.80u L=1.0u
MN5769   0      #2431    #2482    0      MN1      W=    1.80u L=1.0u
MP5768   1      #2431    #2496    1      MP1      W=    1.80u L=1.0u
MP5767   1      #2430    #2495    1      MP1      W=    1.80u L=1.0u
MN5766   0      #2429    #2480    0      MN1      W=    1.80u L=1.0u
MP5765   1      #2429    #2494    1      MP1      W=    1.80u L=1.0u
MP5764   1      #2428    #2493    1      MP1      W=    1.80u L=1.0u
MN5763   0      #2277    #2478    0      MN1      W=    1.80u L=1.0u
MP5762   1      #2443    #2513    1      MP1      W=    1.80u L=1.0u
MP5761   1      X4       #2510    1      MP1      W=   10.80u L=1.0u
MN5760   0      #2443    #2512    0      MN1      W=    1.80u L=1.0u
MN5759   0      X4       #2511    0      MN1      W=    3.60u L=1.0u
MP5758   #2509    #2181    1      1      MP1      W=    5.40u L=1.0u
MN5757   #2508    #2181    0      0      MN1      W=    5.40u L=1.0u
MP5756   #2507    #2278    1      1      MP1      W=    5.40u L=1.0u
MP5755   #2506    #2180    1      1      MP1      W=    5.40u L=1.0u
MP5754   #2505    #2187    1      1      MP1      W=    5.40u L=1.0u
MP5753   #2504    #2179    1      1      MP1      W=    5.40u L=1.0u
MP5752   #2503    #2186    1      1      MP1      W=    5.40u L=1.0u
MP5751   #2502    #2178    1      1      MP1      W=    5.40u L=1.0u
MP5750   #2501    #2185    1      1      MP1      W=    5.40u L=1.0u
MP5749   #2500    #2177    1      1      MP1      W=    5.40u L=1.0u
MP5748   #2499    #2184    1      1      MP1      W=    5.40u L=1.0u
MP5747   #2498    #2176    1      1      MP1      W=    5.40u L=1.0u
MP5746   #2497    #2183    1      1      MP1      W=    5.40u L=1.0u
MP5745   #2496    #2175    1      1      MP1      W=    5.40u L=1.0u
MP5744   #2495    #2182    1      1      MP1      W=    5.40u L=1.0u
MP5743   #2494    #2174    1      1      MP1      W=    5.40u L=1.0u
MP5742   #2493    #2276    1      1      MP1      W=    5.40u L=1.0u
MN5741   #2492    #2180    0      0      MN1      W=    5.40u L=1.0u
MN5740   #2491    #2187    0      0      MN1      W=    5.40u L=1.0u
MN5739   #2490    #2179    0      0      MN1      W=    5.40u L=1.0u
MN5738   #2489    #2186    0      0      MN1      W=    5.40u L=1.0u
MN5737   #2488    #2178    0      0      MN1      W=    5.40u L=1.0u
MN5736   #2487    #2185    0      0      MN1      W=    5.40u L=1.0u
MN5735   #2486    #2177    0      0      MN1      W=    5.40u L=1.0u
MN5734   #2485    #2184    0      0      MN1      W=    5.40u L=1.0u
MN5733   #2484    #2176    0      0      MN1      W=    5.40u L=1.0u
MN5732   #2483    #2183    0      0      MN1      W=    5.40u L=1.0u
MN5731   #2482    #2175    0      0      MN1      W=    5.40u L=1.0u
MN5730   #2481    #2182    0      0      MN1      W=    5.40u L=1.0u
MN5729   #2480    #2174    0      0      MN1      W=    5.40u L=1.0u
MN5728   #2479    #2276    0      0      MN1      W=    5.40u L=1.0u
MN5727   #2478    #2278    0      0      MN1      W=    5.40u L=1.0u
MN5726   #2477    #2406    0      0      MN1      W=    1.80u L=1.0u
MP5725   #2477    #2406    1      1      MP1      W=    1.80u L=1.0u
MN5724   #2444    #2510    0      0      MN1      W=    3.60u L=1.0u
MP5723   #2190    #2510    1      1      MP1      W=   10.80u L=1.0u
MP5722   1      #2423    #2509    1      MP1      W=    5.40u L=1.0u
MN5721   0      #2423    #2508    0      MN1      W=    5.40u L=1.0u
MP5720   1      #2408    #2507    1      MP1      W=    5.40u L=1.0u
MN5719   0      #2422    #2492    0      MN1      W=    5.40u L=1.0u
MP5718   1      #2422    #2506    1      MP1      W=    5.40u L=1.0u
MP5717   1      #2421    #2505    1      MP1      W=    5.40u L=1.0u
MN5716   0      #2421    #2491    0      MN1      W=    5.40u L=1.0u
MN5715   0      #2420    #2490    0      MN1      W=    5.40u L=1.0u
MP5714   1      #2420    #2504    1      MP1      W=    5.40u L=1.0u
MP5713   1      #2419    #2503    1      MP1      W=    5.40u L=1.0u
MN5712   0      #2419    #2489    0      MN1      W=    5.40u L=1.0u
MN5711   0      #2418    #2488    0      MN1      W=    5.40u L=1.0u
MP5710   1      #2418    #2502    1      MP1      W=    5.40u L=1.0u
MP5709   1      #2417    #2501    1      MP1      W=    5.40u L=1.0u
MN5708   0      #2417    #2487    0      MN1      W=    5.40u L=1.0u
MN5707   0      #2416    #2486    0      MN1      W=    5.40u L=1.0u
MP5706   1      #2416    #2500    1      MP1      W=    5.40u L=1.0u
MP5705   1      #2415    #2499    1      MP1      W=    5.40u L=1.0u
MN5704   0      #2415    #2485    0      MN1      W=    5.40u L=1.0u
MN5703   0      #2414    #2484    0      MN1      W=    5.40u L=1.0u
MP5702   1      #2414    #2498    1      MP1      W=    5.40u L=1.0u
MP5701   1      #2413    #2497    1      MP1      W=    5.40u L=1.0u
MN5700   0      #2413    #2483    0      MN1      W=    5.40u L=1.0u
MN5699   0      #2412    #2482    0      MN1      W=    5.40u L=1.0u
MP5698   1      #2412    #2496    1      MP1      W=    5.40u L=1.0u
MP5697   1      #2411    #2495    1      MP1      W=    5.40u L=1.0u
MN5696   0      #2411    #2481    0      MN1      W=    5.40u L=1.0u
MN5695   0      #2410    #2480    0      MN1      W=    5.40u L=1.0u
MP5694   1      #2410    #2494    1      MP1      W=    5.40u L=1.0u
MP5693   1      #2409    #2493    1      MP1      W=    5.40u L=1.0u
MN5692   0      #2409    #2479    0      MN1      W=    5.40u L=1.0u
MN5691   0      #2408    #2478    0      MN1      W=    5.40u L=1.0u
MN5690   #2190    X4       #2444    0      MN1      W=    3.60u L=1.0u
MP5689   #2476    X4       #2190    1      MP1      W=   10.80u L=1.0u
MP5688   #2401    #2368    1      1      MP1      W=   16.20u L=1.0u
MN5687   #2369    #2423    0      0      MN1      W=   10.80u L=1.0u
MP5686   #2460    #2408    1      1      MP1      W=    5.40u L=1.0u
MP5685   #2474    #2422    1      1      MP1      W=    5.40u L=1.0u
MP5684   #2473    #2421    1      1      MP1      W=    5.40u L=1.0u
MP5683   #2472    #2420    1      1      MP1      W=    5.40u L=1.0u
MP5682   #2471    #2419    1      1      MP1      W=    5.40u L=1.0u
MP5681   #2470    #2418    1      1      MP1      W=    5.40u L=1.0u
MP5680   #2469    #2417    1      1      MP1      W=    5.40u L=1.0u
MP5679   #2468    #2416    1      1      MP1      W=    5.40u L=1.0u
MP5678   #2467    #2415    1      1      MP1      W=    5.40u L=1.0u
MP5677   #2466    #2414    1      1      MP1      W=    5.40u L=1.0u
MP5676   #2465    #2413    1      1      MP1      W=    5.40u L=1.0u
MP5675   #2464    #2412    1      1      MP1      W=    5.40u L=1.0u
MP5674   #2463    #2411    1      1      MP1      W=    5.40u L=1.0u
MP5673   #2462    #2410    1      1      MP1      W=    5.40u L=1.0u
MP5672   #2461    #2409    1      1      MP1      W=    5.40u L=1.0u
MN5671   #2459    #2422    0      0      MN1      W=    5.40u L=1.0u
MN5670   #2458    #2421    0      0      MN1      W=    5.40u L=1.0u
MN5669   #2457    #2420    0      0      MN1      W=    5.40u L=1.0u
MN5668   #2456    #2419    0      0      MN1      W=    5.40u L=1.0u
MN5667   #2455    #2418    0      0      MN1      W=    5.40u L=1.0u
MN5666   #2454    #2417    0      0      MN1      W=    5.40u L=1.0u
MN5665   #2453    #2416    0      0      MN1      W=    5.40u L=1.0u
MN5664   #2452    #2415    0      0      MN1      W=    5.40u L=1.0u
MN5663   #2451    #2414    0      0      MN1      W=    5.40u L=1.0u
MN5662   #2450    #2413    0      0      MN1      W=    5.40u L=1.0u
MN5661   #2449    #2412    0      0      MN1      W=    5.40u L=1.0u
MN5660   #2448    #2411    0      0      MN1      W=    5.40u L=1.0u
MN5659   #2447    #2410    0      0      MN1      W=    5.40u L=1.0u
MN5658   #2446    #2409    0      0      MN1      W=    5.40u L=1.0u
MP5657   1      X3       #2476    1      MP1      W=   10.80u L=1.0u
MN5656   #2445    #2408    0      0      MN1      W=    5.40u L=1.0u
MN5655   #2444    X3       #2190    0      MN1      W=    3.60u L=1.0u
MP5654   #2443    #2368    1      1      MP1      W=    5.40u L=1.0u
MN5653   #2442    #2368    #2443    0      MN1      W=    5.40u L=1.0u
MP5652   #2365    #2180    #2474    1      MP1      W=    5.40u L=1.0u
MP5651   #2441    #2187    #2473    1      MP1      W=    5.40u L=1.0u
MP5650   #2440    #2179    #2472    1      MP1      W=    5.40u L=1.0u
MP5649   #2439    #2186    #2471    1      MP1      W=    5.40u L=1.0u
MP5648   #2438    #2178    #2470    1      MP1      W=    5.40u L=1.0u
MP5647   #2437    #2185    #2469    1      MP1      W=    5.40u L=1.0u
MP5646   #2436    #2177    #2468    1      MP1      W=    5.40u L=1.0u
MP5645   #2435    #2184    #2467    1      MP1      W=    5.40u L=1.0u
MP5644   #2434    #2176    #2466    1      MP1      W=    5.40u L=1.0u
MP5643   #2433    #2183    #2465    1      MP1      W=    5.40u L=1.0u
MP5642   #2432    #2175    #2464    1      MP1      W=    5.40u L=1.0u
MP5641   #2431    #2182    #2463    1      MP1      W=    5.40u L=1.0u
MP5640   #2430    #2174    #2462    1      MP1      W=    5.40u L=1.0u
MP5639   #2429    #2276    #2461    1      MP1      W=    5.40u L=1.0u
MP5638   #2428    #2278    #2460    1      MP1      W=    5.40u L=1.0u
MN5637   #2365    #2180    #2459    0      MN1      W=    5.40u L=1.0u
MN5636   #2441    #2187    #2458    0      MN1      W=    5.40u L=1.0u
MN5635   #2440    #2179    #2457    0      MN1      W=    5.40u L=1.0u
MN5634   #2439    #2186    #2456    0      MN1      W=    5.40u L=1.0u
MN5633   #2438    #2178    #2455    0      MN1      W=    5.40u L=1.0u
MN5632   #2437    #2185    #2454    0      MN1      W=    5.40u L=1.0u
MN5631   #2436    #2177    #2453    0      MN1      W=    5.40u L=1.0u
MN5630   #2435    #2184    #2452    0      MN1      W=    5.40u L=1.0u
MN5629   #2434    #2176    #2451    0      MN1      W=    5.40u L=1.0u
MN5628   #2433    #2183    #2450    0      MN1      W=    5.40u L=1.0u
MN5627   #2432    #2175    #2449    0      MN1      W=    5.40u L=1.0u
MN5626   #2431    #2182    #2448    0      MN1      W=    5.40u L=1.0u
MN5625   #2430    #2174    #2447    0      MN1      W=    5.40u L=1.0u
MN5624   #2429    #2276    #2446    0      MN1      W=    5.40u L=1.0u
MN5623   #2428    #2278    #2445    0      MN1      W=    5.40u L=1.0u
MP5622   1      #2181    #2401    1      MP1      W=   10.80u L=1.0u
MN5621   0      #2181    #2369    0      MN1      W=   16.20u L=1.0u
MP5620   #2407    X5       1      1      MP1      W=   10.80u L=1.0u
MP5619   1      #2426    #2443    1      MP1      W=    5.40u L=1.0u
MN5618   0      #2426    #2442    0      MN1      W=    5.40u L=1.0u
MP5617   #2399    #2441    #2365    1      MP1      W=    5.40u L=1.0u
MP5616   #2398    #2440    #2441    1      MP1      W=    5.40u L=1.0u
MP5615   #2397    #2439    #2440    1      MP1      W=    5.40u L=1.0u
MP5614   #2396    #2438    #2439    1      MP1      W=    5.40u L=1.0u
MP5613   #2395    #2437    #2438    1      MP1      W=    5.40u L=1.0u
MP5612   #2394    #2436    #2437    1      MP1      W=    5.40u L=1.0u
MP5611   #2393    #2435    #2436    1      MP1      W=    5.40u L=1.0u
MP5610   #2392    #2434    #2435    1      MP1      W=    5.40u L=1.0u
MP5609   #2391    #2433    #2434    1      MP1      W=    5.40u L=1.0u
MP5608   #2390    #2432    #2433    1      MP1      W=    5.40u L=1.0u
MP5607   #2389    #2431    #2432    1      MP1      W=    5.40u L=1.0u
MP5606   #2388    #2430    #2431    1      MP1      W=    5.40u L=1.0u
MP5605   #2387    #2429    #2430    1      MP1      W=    5.40u L=1.0u
MP5604   #2386    #2428    #2429    1      MP1      W=    5.40u L=1.0u
MP5603   #2385    #2277    #2428    1      MP1      W=    5.40u L=1.0u
MN5602   #2384    #2441    #2365    0      MN1      W=    5.40u L=1.0u
MN5601   #2383    #2440    #2441    0      MN1      W=    5.40u L=1.0u
MN5600   #2382    #2439    #2440    0      MN1      W=    5.40u L=1.0u
MN5599   #2381    #2438    #2439    0      MN1      W=    5.40u L=1.0u
MN5598   #2380    #2437    #2438    0      MN1      W=    5.40u L=1.0u
MN5597   #2379    #2436    #2437    0      MN1      W=    5.40u L=1.0u
MN5596   #2378    #2435    #2436    0      MN1      W=    5.40u L=1.0u
MN5595   #2377    #2434    #2435    0      MN1      W=    5.40u L=1.0u
MN5594   #2376    #2433    #2434    0      MN1      W=    5.40u L=1.0u
MN5593   #2375    #2432    #2433    0      MN1      W=    5.40u L=1.0u
MN5592   #2374    #2431    #2432    0      MN1      W=    5.40u L=1.0u
MN5591   #2373    #2430    #2431    0      MN1      W=    5.40u L=1.0u
MN5590   #2372    #2429    #2430    0      MN1      W=    5.40u L=1.0u
MN5589   #2371    #2428    #2429    0      MN1      W=    5.40u L=1.0u
MN5588   #2370    #2277    #2428    0      MN1      W=    5.40u L=1.0u
MP5587   #2427    #2423    1      1      MP1      W=    5.40u L=1.0u
MP5585   1      X4       #2407    1      MP1      W=   10.80u L=1.0u
MN5584   #2425    X4       #2407    0      MN1      W=    3.60u L=1.0u
MN5583   #2426    #2423    0      0      MN1      W=    5.40u L=1.0u
MP5582   #2426    #2423    1      1      MP1      W=    5.40u L=1.0u
MN5581   0      #2422    #2384    0      MN1      W=   16.20u L=1.0u
MP5580   1      #2422    #2399    1      MP1      W=   16.20u L=1.0u
MP5579   1      #2421    #2398    1      MP1      W=   16.20u L=1.0u
MN5578   0      #2421    #2383    0      MN1      W=   16.20u L=1.0u
MN5577   0      #2420    #2382    0      MN1      W=   16.20u L=1.0u
MP5576   1      #2420    #2397    1      MP1      W=   16.20u L=1.0u
MP5575   1      #2419    #2396    1      MP1      W=   16.20u L=1.0u
MN5574   0      #2419    #2381    0      MN1      W=   16.20u L=1.0u
MN5573   0      #2418    #2380    0      MN1      W=   16.20u L=1.0u
MP5572   1      #2418    #2395    1      MP1      W=   16.20u L=1.0u
MP5571   1      #2417    #2394    1      MP1      W=   16.20u L=1.0u
MN5570   0      #2417    #2379    0      MN1      W=   16.20u L=1.0u
MN5569   0      #2416    #2378    0      MN1      W=   16.20u L=1.0u
MP5568   1      #2416    #2393    1      MP1      W=   16.20u L=1.0u
MP5567   1      #2415    #2392    1      MP1      W=   16.20u L=1.0u
MN5566   0      #2415    #2377    0      MN1      W=   16.20u L=1.0u
MN5565   0      #2414    #2376    0      MN1      W=   16.20u L=1.0u
MP5564   1      #2414    #2391    1      MP1      W=   16.20u L=1.0u
MP5563   1      #2413    #2390    1      MP1      W=   16.20u L=1.0u
MN5562   0      #2413    #2375    0      MN1      W=   16.20u L=1.0u
MN5561   0      #2412    #2374    0      MN1      W=   16.20u L=1.0u
MP5560   1      #2412    #2389    1      MP1      W=   16.20u L=1.0u
MP5559   1      #2411    #2388    1      MP1      W=   16.20u L=1.0u
MN5558   0      #2411    #2373    0      MN1      W=   16.20u L=1.0u
MN5557   0      #2410    #2372    0      MN1      W=   16.20u L=1.0u
MP5556   1      #2410    #2387    1      MP1      W=   16.20u L=1.0u
MP5555   1      #2409    #2386    1      MP1      W=   16.20u L=1.0u
MN5554   0      #2409    #2371    0      MN1      W=   16.20u L=1.0u
MN5553   0      #2408    #2370    0      MN1      W=   16.20u L=1.0u
MP5552   1      #2408    #2385    1      MP1      W=   16.20u L=1.0u
MP5550   #2018    #2181    #2427    1      MP1      W=    5.40u L=1.0u
MN5549   0      X5       #2425    0      MN1      W=    3.60u L=1.0u
MP5518   #2401    #2406    #2018    1      MP1      W=    5.40u L=1.0u
MN5516   #2423    #2365    0      0      MN1      W=    5.40u L=1.0u
MP5515   #2424    #2365    #2423    1      MP1      W=    5.40u L=1.0u
MP5499   1      #2407    #2258    1      MP1      W=   10.80u L=1.0u
MN5483   #2405    #2407    0      0      MN1      W=    3.60u L=1.0u
MP5481   1      #2188    #2424    1      MP1      W=    5.40u L=1.0u
MN5480   #2018    #2406    #2369    0      MN1      W=    5.40u L=1.0u
MN5479   0      #2188    #2423    0      MN1      W=    5.40u L=1.0u
MN5478   #2366    #2190    #2405    0      MN1      W=    3.60u L=1.0u
MP5477   #2258    #2190    1      1      MP1      W=   10.80u L=1.0u
MP5475   #2368    #2188    1      1      MP1      W=    5.40u L=1.0u
MN5474   #2402    #2188    0      0      MN1      W=    5.40u L=1.0u
MN5473   #2384    #2180    0      0      MN1      W=   10.80u L=1.0u
MN5472   #2383    #2187    0      0      MN1      W=   10.80u L=1.0u
MN5471   #2382    #2179    0      0      MN1      W=   10.80u L=1.0u
MN5470   #2381    #2186    0      0      MN1      W=   10.80u L=1.0u
MN5469   #2380    #2178    0      0      MN1      W=   10.80u L=1.0u
MN5468   #2379    #2185    0      0      MN1      W=   10.80u L=1.0u
MN5467   #2378    #2177    0      0      MN1      W=   10.80u L=1.0u
MN5466   #2377    #2184    0      0      MN1      W=   10.80u L=1.0u
MN5465   #2376    #2176    0      0      MN1      W=   10.80u L=1.0u
MN5464   #2375    #2183    0      0      MN1      W=   10.80u L=1.0u
MN5463   #2374    #2175    0      0      MN1      W=   10.80u L=1.0u
MN5462   #2373    #2182    0      0      MN1      W=   10.80u L=1.0u
MN5461   #2372    #2174    0      0      MN1      W=   10.80u L=1.0u
MN5460   #2371    #2276    0      0      MN1      W=   10.80u L=1.0u
MN5459   #2370    #2278    0      0      MN1      W=   10.80u L=1.0u
MN5458   #2403    #2368    #2018    0      MN1      W=    1.80u L=1.0u
MP5457   #2399    #2180    1      1      MP1      W=   10.80u L=1.0u
MP5456   #2398    #2187    1      1      MP1      W=   10.80u L=1.0u
MP5455   #2397    #2179    1      1      MP1      W=   10.80u L=1.0u
MP5454   #2396    #2186    1      1      MP1      W=   10.80u L=1.0u
MP5453   #2395    #2178    1      1      MP1      W=   10.80u L=1.0u
MP5452   #2394    #2185    1      1      MP1      W=   10.80u L=1.0u
MP5451   #2393    #2177    1      1      MP1      W=   10.80u L=1.0u
MP5450   #2392    #2184    1      1      MP1      W=   10.80u L=1.0u
MP5449   #2391    #2176    1      1      MP1      W=   10.80u L=1.0u
MP5448   #2390    #2183    1      1      MP1      W=   10.80u L=1.0u
MP5447   #2389    #2175    1      1      MP1      W=   10.80u L=1.0u
MP5446   #2388    #2182    1      1      MP1      W=   10.80u L=1.0u
MP5445   #2387    #2174    1      1      MP1      W=   10.80u L=1.0u
MP5444   #2386    #2276    1      1      MP1      W=   10.80u L=1.0u
MP5443   #2385    #2278    1      1      MP1      W=   10.80u L=1.0u
MN5442   #2258    X4       #2366    0      MN1      W=    3.60u L=1.0u
MP5441   #2400    X4       #2258    1      MP1      W=   10.80u L=1.0u
MN5440   #2369    #2181    #2403    0      MN1      W=    1.80u L=1.0u
MN5439   #2368    #2365    #2402    0      MN1      W=    5.40u L=1.0u
MP5437   1      #2365    #2368    1      MP1      W=    5.40u L=1.0u
MP5436   1      X5       #2400    1      MP1      W=   10.80u L=1.0u
MN5405   #2366    X5       #2258    0      MN1      W=    3.60u L=1.0u
MN5404   0      #2224    #2295    0      MN1      W=    3.60u L=1.0u
MN5403   0      #2223    #2287    0      MN1      W=    3.60u L=1.0u
MN5402   0      #2239    #2294    0      MN1      W=    3.60u L=1.0u
MN5401   0      #2238    #2285    0      MN1      W=    3.60u L=1.0u
MN5400   0      #2237    #2293    0      MN1      W=    3.60u L=1.0u
MN5399   0      #2236    #2284    0      MN1      W=    3.60u L=1.0u
MN5398   0      #2235    #2292    0      MN1      W=    3.60u L=1.0u
MN5397   0      #2234    #2283    0      MN1      W=    3.60u L=1.0u
MN5396   0      #2233    #2291    0      MN1      W=    3.60u L=1.0u
MN5395   0      #2232    #2282    0      MN1      W=    3.60u L=1.0u
MN5394   0      #2231    #2290    0      MN1      W=    3.60u L=1.0u
MN5393   0      #2230    #2281    0      MN1      W=    3.60u L=1.0u
MN5392   0      #2229    #2289    0      MN1      W=    3.60u L=1.0u
MN5391   0      #2228    #2280    0      MN1      W=    3.60u L=1.0u
MN5390   0      #2227    #2288    0      MN1      W=    3.60u L=1.0u
MP5389   1      #2224    #2295    1      MP1      W=    3.60u L=1.0u
MP5388   1      #2223    #2287    1      MP1      W=    3.60u L=1.0u
MP5387   1      #2239    #2294    1      MP1      W=    3.60u L=1.0u
MP5386   1      #2238    #2285    1      MP1      W=    3.60u L=1.0u
MP5385   1      #2237    #2293    1      MP1      W=    3.60u L=1.0u
MP5384   1      #2236    #2284    1      MP1      W=    3.60u L=1.0u
MP5383   1      #2235    #2292    1      MP1      W=    3.60u L=1.0u
MP5382   1      #2234    #2283    1      MP1      W=    3.60u L=1.0u
MP5381   1      #2233    #2291    1      MP1      W=    3.60u L=1.0u
MP5380   1      #2232    #2282    1      MP1      W=    3.60u L=1.0u
MP5379   1      #2231    #2290    1      MP1      W=    3.60u L=1.0u
MP5378   1      #2230    #2281    1      MP1      W=    3.60u L=1.0u
MP5377   1      #2229    #2289    1      MP1      W=    3.60u L=1.0u
MP5376   1      #2228    #2280    1      MP1      W=    3.60u L=1.0u
MP5375   1      #2227    #2288    1      MP1      W=    3.60u L=1.0u
MP5374   1      #2226    #2279    1      MP1      W=    3.60u L=1.0u
MN5373   0      #2226    #2279    0      MN1      W=    3.60u L=1.0u
MP5372   1      #2240    #2286    1      MP1      W=    3.60u L=1.0u
MP5371   #2330    #2278    1      1      MP1      W=   21.60u L=1.0u
MN5370   0      #2240    #2286    0      MN1      W=    3.60u L=1.0u
MN5369   #2330    #2278    0      0      MN1      W=    7.20u L=1.0u
MP5366   #2364    #2295    1      1      MP1      W=    3.60u L=1.0u
MP5365   #2363    #2287    1      1      MP1      W=    3.60u L=1.0u
MP5364   #2362    #2239    1      1      MP1      W=    3.60u L=1.0u
MP5363   #2361    #2285    1      1      MP1      W=    3.60u L=1.0u
MP5362   #2360    #2237    1      1      MP1      W=    3.60u L=1.0u
MP5361   #2359    #2284    1      1      MP1      W=    3.60u L=1.0u
MP5360   #2358    #2235    1      1      MP1      W=    3.60u L=1.0u
MP5359   #2357    #2283    1      1      MP1      W=    3.60u L=1.0u
MP5358   #2356    #2233    1      1      MP1      W=    3.60u L=1.0u
MP5357   #2355    #2282    1      1      MP1      W=    3.60u L=1.0u
MP5356   #2354    #2231    1      1      MP1      W=    3.60u L=1.0u
MP5355   #2353    #2281    1      1      MP1      W=    3.60u L=1.0u
MP5354   #2352    #2229    1      1      MP1      W=    3.60u L=1.0u
MP5353   #2351    #2280    1      1      MP1      W=    3.60u L=1.0u
MP5352   #2350    #2227    1      1      MP1      W=    3.60u L=1.0u
MP5351   #2349    #2279    1      1      MP1      W=    3.60u L=1.0u
MP5350   #2348    #2240    1      1      MP1      W=    3.60u L=1.0u
MN5349   #2347    #2224    0      0      MN1      W=    3.60u L=1.0u
MN5348   #2346    #2223    0      0      MN1      W=    3.60u L=1.0u
MN5347   #2345    #2294    0      0      MN1      W=    3.60u L=1.0u
MN5346   #2344    #2238    0      0      MN1      W=    3.60u L=1.0u
MN5345   #2343    #2293    0      0      MN1      W=    3.60u L=1.0u
MN5344   #2342    #2236    0      0      MN1      W=    3.60u L=1.0u
MN5343   #2341    #2292    0      0      MN1      W=    3.60u L=1.0u
MN5342   #2340    #2234    0      0      MN1      W=    3.60u L=1.0u
MN5341   #2339    #2291    0      0      MN1      W=    3.60u L=1.0u
MN5340   #2338    #2232    0      0      MN1      W=    3.60u L=1.0u
MN5339   #2337    #2290    0      0      MN1      W=    3.60u L=1.0u
MN5338   #2336    #2230    0      0      MN1      W=    3.60u L=1.0u
MN5337   #2335    #2289    0      0      MN1      W=    3.60u L=1.0u
MN5336   #2334    #2228    0      0      MN1      W=    3.60u L=1.0u
MN5335   #2333    #2288    0      0      MN1      W=    3.60u L=1.0u
MN5334   #2332    #2226    0      0      MN1      W=    3.60u L=1.0u
MN5333   #2331    #2286    0      0      MN1      W=    3.60u L=1.0u
MP5332   #2274    #2330    #2364    1      MP1      W=    3.60u L=1.0u
MP5331   #2273    #2330    #2363    1      MP1      W=    3.60u L=1.0u
MP5330   #2272    #2330    #2362    1      MP1      W=    3.60u L=1.0u
MP5329   #2271    #2330    #2361    1      MP1      W=    3.60u L=1.0u
MP5328   #2270    #2330    #2360    1      MP1      W=    3.60u L=1.0u
MP5327   #2269    #2330    #2359    1      MP1      W=    3.60u L=1.0u
MP5326   #2268    #2330    #2358    1      MP1      W=    3.60u L=1.0u
MP5325   #2267    #2330    #2357    1      MP1      W=    3.60u L=1.0u
MP5324   #2266    #2330    #2356    1      MP1      W=    3.60u L=1.0u
MP5323   #2265    #2330    #2355    1      MP1      W=    3.60u L=1.0u
MP5322   #2264    #2330    #2354    1      MP1      W=    3.60u L=1.0u
MP5321   #2263    #2330    #2353    1      MP1      W=    3.60u L=1.0u
MP5320   #2262    #2330    #2352    1      MP1      W=    3.60u L=1.0u
MP5319   #2261    #2330    #2351    1      MP1      W=    3.60u L=1.0u
MP5318   #2260    #2330    #2350    1      MP1      W=    3.60u L=1.0u
MP5317   #2259    #2330    #2349    1      MP1      W=    3.60u L=1.0u
MN5316   #2274    #2330    #2347    0      MN1      W=    3.60u L=1.0u
MN5315   #2273    #2330    #2346    0      MN1      W=    3.60u L=1.0u
MN5314   #2272    #2330    #2345    0      MN1      W=    3.60u L=1.0u
MN5313   #2271    #2330    #2344    0      MN1      W=    3.60u L=1.0u
MN5312   #2270    #2330    #2343    0      MN1      W=    3.60u L=1.0u
MN5311   #2269    #2330    #2342    0      MN1      W=    3.60u L=1.0u
MN5310   #2268    #2330    #2341    0      MN1      W=    3.60u L=1.0u
MN5309   #2267    #2330    #2340    0      MN1      W=    3.60u L=1.0u
MN5308   #2266    #2330    #2339    0      MN1      W=    3.60u L=1.0u
MN5307   #2265    #2330    #2338    0      MN1      W=    3.60u L=1.0u
MN5306   #2264    #2330    #2337    0      MN1      W=    3.60u L=1.0u
MN5305   #2263    #2330    #2336    0      MN1      W=    3.60u L=1.0u
MN5304   #2262    #2330    #2335    0      MN1      W=    3.60u L=1.0u
MN5303   #2261    #2330    #2334    0      MN1      W=    3.60u L=1.0u
MN5302   #2260    #2330    #2333    0      MN1      W=    3.60u L=1.0u
MN5301   #2259    #2330    #2332    0      MN1      W=    3.60u L=1.0u
MP5300   #2275    #2330    #2348    1      MP1      W=    3.60u L=1.0u
MN5299   #2275    #2330    #2331    0      MN1      W=    3.60u L=1.0u
MP5298   #2278    X5       1      1      MP1      W=   21.60u L=1.0u
MN5297   #2278    X5       0      0      MN1      W=    7.20u L=1.0u
MN5296   #2312    #2278    #2274    0      MN1      W=    3.60u L=1.0u
MP5295   #2329    #2278    #2274    1      MP1      W=    3.60u L=1.0u
MP5294   #2327    #2278    #2273    1      MP1      W=    3.60u L=1.0u
MN5293   #2310    #2278    #2272    0      MN1      W=    3.60u L=1.0u
MP5292   #2326    #2278    #2272    1      MP1      W=    3.60u L=1.0u
MP5291   #2325    #2278    #2271    1      MP1      W=    3.60u L=1.0u
MN5290   #2308    #2278    #2270    0      MN1      W=    3.60u L=1.0u
MP5289   #2324    #2278    #2270    1      MP1      W=    3.60u L=1.0u
MP5288   #2323    #2278    #2269    1      MP1      W=    3.60u L=1.0u
MN5287   #2306    #2278    #2268    0      MN1      W=    3.60u L=1.0u
MP5286   #2322    #2278    #2268    1      MP1      W=    3.60u L=1.0u
MP5285   #2321    #2278    #2267    1      MP1      W=    3.60u L=1.0u
MN5284   #2304    #2278    #2266    0      MN1      W=    3.60u L=1.0u
MP5283   #2320    #2278    #2266    1      MP1      W=    3.60u L=1.0u
MP5282   #2319    #2278    #2265    1      MP1      W=    3.60u L=1.0u
MN5281   #2302    #2278    #2264    0      MN1      W=    3.60u L=1.0u
MP5280   #2318    #2278    #2264    1      MP1      W=    3.60u L=1.0u
MP5279   #2317    #2278    #2263    1      MP1      W=    3.60u L=1.0u
MN5278   #2300    #2278    #2262    0      MN1      W=    3.60u L=1.0u
MP5277   #2316    #2278    #2262    1      MP1      W=    3.60u L=1.0u
MP5276   #2315    #2278    #2261    1      MP1      W=    3.60u L=1.0u
MN5275   #2298    #2278    #2260    0      MN1      W=    3.60u L=1.0u
MP5274   #2314    #2278    #2260    1      MP1      W=    3.60u L=1.0u
MP5273   #2313    #2278    #2259    1      MP1      W=    3.60u L=1.0u
MN5272   #2297    #2278    #2259    0      MN1      W=    3.60u L=1.0u
MN5271   #2311    #2278    #2273    0      MN1      W=    3.60u L=1.0u
MN5270   #2309    #2278    #2271    0      MN1      W=    3.60u L=1.0u
MN5269   #2307    #2278    #2269    0      MN1      W=    3.60u L=1.0u
MN5268   #2305    #2278    #2267    0      MN1      W=    3.60u L=1.0u
MN5267   #2303    #2278    #2265    0      MN1      W=    3.60u L=1.0u
MN5266   #2301    #2278    #2263    0      MN1      W=    3.60u L=1.0u
MN5265   #2299    #2278    #2261    0      MN1      W=    3.60u L=1.0u
MN5264   #2296    #2278    #2275    0      MN1      W=    3.60u L=1.0u
MP5263   #2328    #2278    #2275    1      MP1      W=    3.60u L=1.0u
MP5260   1      #2224    #2329    1      MP1      W=    3.60u L=1.0u
MP5259   1      #2286    #2328    1      MP1      W=    3.60u L=1.0u
MN5258   0      #2295    #2312    0      MN1      W=    3.60u L=1.0u
MP5257   1      #2223    #2327    1      MP1      W=    3.60u L=1.0u
MN5256   0      #2287    #2311    0      MN1      W=    3.60u L=1.0u
MN5255   0      #2239    #2310    0      MN1      W=    3.60u L=1.0u
MP5254   1      #2294    #2326    1      MP1      W=    3.60u L=1.0u
MP5253   1      #2238    #2325    1      MP1      W=    3.60u L=1.0u
MN5252   0      #2285    #2309    0      MN1      W=    3.60u L=1.0u
MN5251   0      #2237    #2308    0      MN1      W=    3.60u L=1.0u
MP5250   1      #2293    #2324    1      MP1      W=    3.60u L=1.0u
MP5249   1      #2236    #2323    1      MP1      W=    3.60u L=1.0u
MN5248   0      #2284    #2307    0      MN1      W=    3.60u L=1.0u
MN5247   0      #2235    #2306    0      MN1      W=    3.60u L=1.0u
MP5246   1      #2292    #2322    1      MP1      W=    3.60u L=1.0u
MP5245   1      #2234    #2321    1      MP1      W=    3.60u L=1.0u
MN5244   0      #2283    #2305    0      MN1      W=    3.60u L=1.0u
MN5243   0      #2233    #2304    0      MN1      W=    3.60u L=1.0u
MP5242   1      #2291    #2320    1      MP1      W=    3.60u L=1.0u
MP5241   1      #2232    #2319    1      MP1      W=    3.60u L=1.0u
MN5240   0      #2282    #2303    0      MN1      W=    3.60u L=1.0u
MN5239   0      #2231    #2302    0      MN1      W=    3.60u L=1.0u
MP5238   1      #2290    #2318    1      MP1      W=    3.60u L=1.0u
MP5237   1      #2230    #2317    1      MP1      W=    3.60u L=1.0u
MN5236   0      #2281    #2301    0      MN1      W=    3.60u L=1.0u
MN5235   0      #2229    #2300    0      MN1      W=    3.60u L=1.0u
MP5234   1      #2289    #2316    1      MP1      W=    3.60u L=1.0u
MP5233   1      #2228    #2315    1      MP1      W=    3.60u L=1.0u
MN5232   0      #2280    #2299    0      MN1      W=    3.60u L=1.0u
MN5231   0      #2227    #2298    0      MN1      W=    3.60u L=1.0u
MP5230   1      #2288    #2314    1      MP1      W=    3.60u L=1.0u
MP5229   1      #2226    #2313    1      MP1      W=    3.60u L=1.0u
MN5228   0      #2279    #2297    0      MN1      W=    3.60u L=1.0u
MN5227   0      #2240    #2296    0      MN1      W=    3.60u L=1.0u
MN5226   #2225    #2258    0      0      MN1      W=   14.40u L=1.0u
MP5225   #2225    #2258    1      1      MP1      W=   43.20u L=1.0u
MP5224   #2277    #2275    1      1      MP1      W=   10.80u L=1.0u
MN5223   #1999    #2274    0      0      MN1      W=   10.80u L=1.0u
MN5222   #1998    #2273    0      0      MN1      W=   10.80u L=1.0u
MN5221   #1997    #2272    0      0      MN1      W=   10.80u L=1.0u
MN5220   #1996    #2271    0      0      MN1      W=   10.80u L=1.0u
MN5219   #1995    #2270    0      0      MN1      W=   10.80u L=1.0u
MN5218   #1994    #2269    0      0      MN1      W=   10.80u L=1.0u
MN5217   #1993    #2268    0      0      MN1      W=   10.80u L=1.0u
MN5216   #1992    #2267    0      0      MN1      W=   10.80u L=1.0u
MN5215   #1991    #2266    0      0      MN1      W=   10.80u L=1.0u
MN5214   #1990    #2265    0      0      MN1      W=   10.80u L=1.0u
MN5213   #1989    #2264    0      0      MN1      W=   10.80u L=1.0u
MN5212   #1988    #2263    0      0      MN1      W=   10.80u L=1.0u
MN5211   #1987    #2262    0      0      MN1      W=   10.80u L=1.0u
MN5210   #1986    #2261    0      0      MN1      W=   10.80u L=1.0u
MN5209   #1985    #2260    0      0      MN1      W=   10.80u L=1.0u
MN5208   #2276    #2259    0      0      MN1      W=   10.80u L=1.0u
MN5207   #2277    #2275    0      0      MN1      W=   10.80u L=1.0u
MP5206   #1999    #2274    1      1      MP1      W=   10.80u L=1.0u
MP5205   #1998    #2273    1      1      MP1      W=   10.80u L=1.0u
MP5204   #1997    #2272    1      1      MP1      W=   10.80u L=1.0u
MP5203   #1996    #2271    1      1      MP1      W=   10.80u L=1.0u
MP5202   #1995    #2270    1      1      MP1      W=   10.80u L=1.0u
MP5201   #1994    #2269    1      1      MP1      W=   10.80u L=1.0u
MP5200   #1993    #2268    1      1      MP1      W=   10.80u L=1.0u
MP5199   #1992    #2267    1      1      MP1      W=   10.80u L=1.0u
MP5198   #1991    #2266    1      1      MP1      W=   10.80u L=1.0u
MP5197   #1990    #2265    1      1      MP1      W=   10.80u L=1.0u
MP5196   #1989    #2264    1      1      MP1      W=   10.80u L=1.0u
MP5195   #1988    #2263    1      1      MP1      W=   10.80u L=1.0u
MP5194   #1987    #2262    1      1      MP1      W=   10.80u L=1.0u
MP5193   #1986    #2261    1      1      MP1      W=   10.80u L=1.0u
MP5192   #1985    #2260    1      1      MP1      W=   10.80u L=1.0u
MP5191   #2276    #2259    1      1      MP1      W=   10.80u L=1.0u
MP5152   #2192    #2225    1      1      MP1      W=    3.60u L=1.0u
MP5151   #2191    #2225    1      1      MP1      W=    3.60u L=1.0u
MP5150   #2207    #2225    1      1      MP1      W=    3.60u L=1.0u
MP5149   #2206    #2225    1      1      MP1      W=    3.60u L=1.0u
MP5148   #2205    #2225    1      1      MP1      W=    3.60u L=1.0u
MP5147   #2204    #2225    1      1      MP1      W=    3.60u L=1.0u
MP5146   #2203    #2225    1      1      MP1      W=    3.60u L=1.0u
MP5145   #2202    #2225    1      1      MP1      W=    3.60u L=1.0u
MP5144   #2201    #2225    1      1      MP1      W=    3.60u L=1.0u
MP5143   #2200    #2225    1      1      MP1      W=    3.60u L=1.0u
MP5142   #2199    #2225    1      1      MP1      W=    3.60u L=1.0u
MP5141   #2198    #2225    1      1      MP1      W=    3.60u L=1.0u
MP5140   #2197    #2225    1      1      MP1      W=    3.60u L=1.0u
MP5139   #2196    #2225    1      1      MP1      W=    3.60u L=1.0u
MP5138   #2195    #2225    1      1      MP1      W=    3.60u L=1.0u
MP5137   #2194    #2225    1      1      MP1      W=    3.60u L=1.0u
MP5136   #2240    #2189    1      1      MP1      W=    3.60u L=1.0u
MN5135   #2257    #2189    0      0      MN1      W=    3.60u L=1.0u
MN5134   #2256    #2189    0      0      MN1      W=    3.60u L=1.0u
MN5133   #2255    #2189    0      0      MN1      W=    3.60u L=1.0u
MN5132   #2254    #2189    0      0      MN1      W=    3.60u L=1.0u
MN5131   #2253    #2189    0      0      MN1      W=    3.60u L=1.0u
MN5130   #2252    #2189    0      0      MN1      W=    3.60u L=1.0u
MN5129   #2251    #2189    0      0      MN1      W=    3.60u L=1.0u
MN5128   #2250    #2189    0      0      MN1      W=    3.60u L=1.0u
MN5127   #2249    #2189    0      0      MN1      W=    3.60u L=1.0u
MN5126   #2248    #2189    0      0      MN1      W=    3.60u L=1.0u
MN5125   #2247    #2189    0      0      MN1      W=    3.60u L=1.0u
MN5124   #2246    #2189    0      0      MN1      W=    3.60u L=1.0u
MN5123   #2245    #2189    0      0      MN1      W=    3.60u L=1.0u
MN5122   #2244    #2189    0      0      MN1      W=    3.60u L=1.0u
MN5121   #2243    #2189    0      0      MN1      W=    3.60u L=1.0u
MN5120   #2242    #2189    0      0      MN1      W=    3.60u L=1.0u
MN5117   #2241    #2189    0      0      MN1      W=    3.60u L=1.0u
MP5116   #2239    #51      #2207    1      MP1      W=    3.60u L=1.0u
MP5115   #2238    #50      #2206    1      MP1      W=    3.60u L=1.0u
MP5114   #2237    #49      #2205    1      MP1      W=    3.60u L=1.0u
MP5113   #2236    #48      #2204    1      MP1      W=    3.60u L=1.0u
MP5112   #2235    #47      #2203    1      MP1      W=    3.60u L=1.0u
MP5111   #2234    #46      #2202    1      MP1      W=    3.60u L=1.0u
MP5110   #2233    #45      #2201    1      MP1      W=    3.60u L=1.0u
MP5109   #2232    #44      #2200    1      MP1      W=    3.60u L=1.0u
MP5108   #2231    #43      #2199    1      MP1      W=    3.60u L=1.0u
MP5107   #2230    #42      #2198    1      MP1      W=    3.60u L=1.0u
MP5106   #2229    #41      #2197    1      MP1      W=    3.60u L=1.0u
MP5105   #2228    #40      #2196    1      MP1      W=    3.60u L=1.0u
MP5104   #2227    #39      #2195    1      MP1      W=    3.60u L=1.0u
MP5103   #2226    #38      #2194    1      MP1      W=    3.60u L=1.0u
MN5102   #2223    #52      #2257    0      MN1      W=    3.60u L=1.0u
MN5101   #2239    #51      #2256    0      MN1      W=    3.60u L=1.0u
MN5100   #2238    #50      #2255    0      MN1      W=    3.60u L=1.0u
MN5099   #2237    #49      #2254    0      MN1      W=    3.60u L=1.0u
MN5098   #2236    #48      #2253    0      MN1      W=    3.60u L=1.0u
MN5097   #2235    #47      #2252    0      MN1      W=    3.60u L=1.0u
MN5096   #2234    #46      #2251    0      MN1      W=    3.60u L=1.0u
MN5095   #2233    #45      #2250    0      MN1      W=    3.60u L=1.0u
MN5094   #2232    #44      #2249    0      MN1      W=    3.60u L=1.0u
MN5093   #2231    #43      #2248    0      MN1      W=    3.60u L=1.0u
MN5092   #2230    #42      #2247    0      MN1      W=    3.60u L=1.0u
MN5091   #2229    #41      #2246    0      MN1      W=    3.60u L=1.0u
MN5090   #2228    #40      #2245    0      MN1      W=    3.60u L=1.0u
MN5089   #2227    #39      #2244    0      MN1      W=    3.60u L=1.0u
MN5088   #2226    #38      #2243    0      MN1      W=    3.60u L=1.0u
MN5087   #2240    #37      #2242    0      MN1      W=    3.60u L=1.0u
MP5086   1      #37      #2240    1      MP1      W=    3.60u L=1.0u
MP5085   #2223    #52      #2191    1      MP1      W=    3.60u L=1.0u
MP5084   #2224    #52      #2192    1      MP1      W=    3.60u L=1.0u
MN5083   #2189    #2190    0      0      MN1      W=   14.40u L=1.0u
MN5082   #2224    #52      #2241    0      MN1      W=    3.60u L=1.0u
MP5081   #2189    #2190    1      1      MP1      W=   43.20u L=1.0u
MN5080   #2222    #2225    #2223    0      MN1      W=    3.60u L=1.0u
MN5079   #2221    #2225    #2239    0      MN1      W=    3.60u L=1.0u
MN5078   #2220    #2225    #2238    0      MN1      W=    3.60u L=1.0u
MN5077   #2219    #2225    #2237    0      MN1      W=    3.60u L=1.0u
MN5076   #2218    #2225    #2236    0      MN1      W=    3.60u L=1.0u
MN5075   #2217    #2225    #2235    0      MN1      W=    3.60u L=1.0u
MN5074   #2216    #2225    #2234    0      MN1      W=    3.60u L=1.0u
MN5073   #2215    #2225    #2233    0      MN1      W=    3.60u L=1.0u
MN5072   #2214    #2225    #2232    0      MN1      W=    3.60u L=1.0u
MN5071   #2213    #2225    #2231    0      MN1      W=    3.60u L=1.0u
MN5070   #2212    #2225    #2230    0      MN1      W=    3.60u L=1.0u
MN5069   #2211    #2225    #2229    0      MN1      W=    3.60u L=1.0u
MN5068   #2210    #2225    #2228    0      MN1      W=    3.60u L=1.0u
MN5067   #2209    #2225    #2227    0      MN1      W=    3.60u L=1.0u
MP5066   #2207    #2189    #2239    1      MP1      W=    3.60u L=1.0u
MP5065   #2206    #2189    #2238    1      MP1      W=    3.60u L=1.0u
MP5064   #2205    #2189    #2237    1      MP1      W=    3.60u L=1.0u
MP5063   #2204    #2189    #2236    1      MP1      W=    3.60u L=1.0u
MP5062   #2203    #2189    #2235    1      MP1      W=    3.60u L=1.0u
MP5061   #2202    #2189    #2234    1      MP1      W=    3.60u L=1.0u
MP5060   #2201    #2189    #2233    1      MP1      W=    3.60u L=1.0u
MP5059   #2200    #2189    #2232    1      MP1      W=    3.60u L=1.0u
MP5058   #2199    #2189    #2231    1      MP1      W=    3.60u L=1.0u
MP5057   #2198    #2189    #2230    1      MP1      W=    3.60u L=1.0u
MP5056   #2197    #2189    #2229    1      MP1      W=    3.60u L=1.0u
MP5055   #2196    #2189    #2228    1      MP1      W=    3.60u L=1.0u
MP5054   #2195    #2189    #2227    1      MP1      W=    3.60u L=1.0u
MP5053   #2194    #2189    #2226    1      MP1      W=    3.60u L=1.0u
MN5052   #2208    #2225    #2226    0      MN1      W=    3.60u L=1.0u
MN5051   #2193    #2225    #2224    0      MN1      W=    3.60u L=1.0u
MP5048   #2192    #2189    #2224    1      MP1      W=    3.60u L=1.0u
MP5047   #2191    #2189    #2223    1      MP1      W=    3.60u L=1.0u
MN5046   0      #51      #2222    0      MN1      W=    3.60u L=1.0u
MN5045   0      #50      #2221    0      MN1      W=    3.60u L=1.0u
MN5044   0      #49      #2220    0      MN1      W=    3.60u L=1.0u
MN5043   0      #48      #2219    0      MN1      W=    3.60u L=1.0u
MN5042   0      #47      #2218    0      MN1      W=    3.60u L=1.0u
MN5041   0      #46      #2217    0      MN1      W=    3.60u L=1.0u
MN5040   0      #45      #2216    0      MN1      W=    3.60u L=1.0u
MN5039   0      #44      #2215    0      MN1      W=    3.60u L=1.0u
MN5038   0      #43      #2214    0      MN1      W=    3.60u L=1.0u
MN5037   0      #42      #2213    0      MN1      W=    3.60u L=1.0u
MN5036   0      #41      #2212    0      MN1      W=    3.60u L=1.0u
MN5035   0      #40      #2211    0      MN1      W=    3.60u L=1.0u
MN5034   0      #39      #2210    0      MN1      W=    3.60u L=1.0u
MN5033   0      #38      #2209    0      MN1      W=    3.60u L=1.0u
MN5032   0      #37      #2208    0      MN1      W=    3.60u L=1.0u
MP5031   1      #50      #2207    1      MP1      W=    3.60u L=1.0u
MP5030   1      #49      #2206    1      MP1      W=    3.60u L=1.0u
MP5029   1      #48      #2205    1      MP1      W=    3.60u L=1.0u
MP5028   1      #47      #2204    1      MP1      W=    3.60u L=1.0u
MP5027   1      #46      #2203    1      MP1      W=    3.60u L=1.0u
MP5026   1      #45      #2202    1      MP1      W=    3.60u L=1.0u
MP5025   1      #44      #2201    1      MP1      W=    3.60u L=1.0u
MP5024   1      #43      #2200    1      MP1      W=    3.60u L=1.0u
MP5023   1      #42      #2199    1      MP1      W=    3.60u L=1.0u
MP5022   1      #41      #2198    1      MP1      W=    3.60u L=1.0u
MP5021   1      #40      #2197    1      MP1      W=    3.60u L=1.0u
MP5020   1      #39      #2196    1      MP1      W=    3.60u L=1.0u
MP5019   1      #38      #2195    1      MP1      W=    3.60u L=1.0u
MP5018   1      #37      #2194    1      MP1      W=    3.60u L=1.0u
MN5017   0      #52      #2193    0      MN1      W=    3.60u L=1.0u
MP5016   1      #52      #2192    1      MP1      W=    3.60u L=1.0u
MP5015   1      #51      #2191    1      MP1      W=    3.60u L=1.0u
MN5012   #2174    #2091    0      0      MN1      W=   10.80u L=1.0u
MP5011   #2174    #2091    1      1      MP1      W=   10.80u L=1.0u
MN5010   #2181    #2098    0      0      MN1      W=   10.80u L=1.0u
MN5009   #2188    #2105    0      0      MN1      W=   10.80u L=1.0u
MN5008   #2180    #2097    0      0      MN1      W=   10.80u L=1.0u
MN5007   #2187    #2104    0      0      MN1      W=   10.80u L=1.0u
MN5006   #2179    #2096    0      0      MN1      W=   10.80u L=1.0u
MN5005   #2186    #2103    0      0      MN1      W=   10.80u L=1.0u
MN5004   #2178    #2095    0      0      MN1      W=   10.80u L=1.0u
MN5003   #2185    #2102    0      0      MN1      W=   10.80u L=1.0u
MN5002   #2177    #2094    0      0      MN1      W=   10.80u L=1.0u
MN5001   #2184    #2101    0      0      MN1      W=   10.80u L=1.0u
MN5000   #2176    #2093    0      0      MN1      W=   10.80u L=1.0u
MN4999   #2183    #2100    0      0      MN1      W=   10.80u L=1.0u
MN4998   #2175    #2092    0      0      MN1      W=   10.80u L=1.0u
MN4997   #2182    #2099    0      0      MN1      W=   10.80u L=1.0u
MP4996   #2181    #2098    1      1      MP1      W=   10.80u L=1.0u
MP4995   #2188    #2105    1      1      MP1      W=   10.80u L=1.0u
MP4994   #2180    #2097    1      1      MP1      W=   10.80u L=1.0u
MP4993   #2187    #2104    1      1      MP1      W=   10.80u L=1.0u
MP4992   #2179    #2096    1      1      MP1      W=   10.80u L=1.0u
MP4991   #2186    #2103    1      1      MP1      W=   10.80u L=1.0u
MP4990   #2178    #2095    1      1      MP1      W=   10.80u L=1.0u
MP4989   #2185    #2102    1      1      MP1      W=   10.80u L=1.0u
MP4988   #2177    #2094    1      1      MP1      W=   10.80u L=1.0u
MP4987   #2184    #2101    1      1      MP1      W=   10.80u L=1.0u
MP4986   #2176    #2093    1      1      MP1      W=   10.80u L=1.0u
MP4985   #2183    #2100    1      1      MP1      W=   10.80u L=1.0u
MP4984   #2175    #2092    1      1      MP1      W=   10.80u L=1.0u
MP4983   #2182    #2099    1      1      MP1      W=   10.80u L=1.0u
MN4964   0      #2018    #2154    0      MN1      W=    1.80u L=1.0u
MN4949   Z21      #2106    0      0      MN1      W=    3.60u L=1.0u
MP4948   #2173    #2019    1      1      MP1      W=    1.80u L=1.0u
MP4947   Z21      #2106    1      1      MP1      W=    3.60u L=1.0u
MN4946   #2139    #1985    0      0      MN1      W=    5.40u L=1.0u
MP4945   #2170    #1985    1      1      MP1      W=    5.40u L=1.0u
MN4944   #2154    #2019    0      0      MN1      W=    1.80u L=1.0u
MN4943   #2153    #1999    0      0      MN1      W=    5.40u L=1.0u
MN4942   #2151    #1997    0      0      MN1      W=    5.40u L=1.0u
MN4941   #2149    #1995    0      0      MN1      W=    5.40u L=1.0u
MN4940   #2147    #1993    0      0      MN1      W=    5.40u L=1.0u
MN4939   #2145    #1991    0      0      MN1      W=    5.40u L=1.0u
MN4938   #2143    #1989    0      0      MN1      W=    5.40u L=1.0u
MN4937   #2141    #1987    0      0      MN1      W=    5.40u L=1.0u
MP4936   #2169    #1999    1      1      MP1      W=    5.40u L=1.0u
MP4935   #2167    #1997    1      1      MP1      W=    5.40u L=1.0u
MP4934   #2165    #1995    1      1      MP1      W=    5.40u L=1.0u
MP4933   #2163    #1993    1      1      MP1      W=    5.40u L=1.0u
MP4932   #2161    #1991    1      1      MP1      W=    5.40u L=1.0u
MP4931   #2159    #1989    1      1      MP1      W=    5.40u L=1.0u
MP4930   #2157    #1987    1      1      MP1      W=    5.40u L=1.0u
MP4929   #2171    #1756    1      1      MP1      W=    5.40u L=1.0u
MP4928   #2106    #2018    #2173    1      MP1      W=    1.80u L=1.0u
MP4927   #2168    #1998    1      1      MP1      W=    5.40u L=1.0u
MP4926   #2166    #1996    1      1      MP1      W=    5.40u L=1.0u
MP4925   #2164    #1994    1      1      MP1      W=    5.40u L=1.0u
MP4924   #2162    #1992    1      1      MP1      W=    5.40u L=1.0u
MP4923   #2160    #1990    1      1      MP1      W=    5.40u L=1.0u
MP4922   #2158    #1988    1      1      MP1      W=    5.40u L=1.0u
MP4921   #2156    #1986    1      1      MP1      W=    5.40u L=1.0u
MN4920   #2152    #1998    0      0      MN1      W=    5.40u L=1.0u
MN4919   #2150    #1996    0      0      MN1      W=    5.40u L=1.0u
MN4918   #2148    #1994    0      0      MN1      W=    5.40u L=1.0u
MN4917   #2146    #1992    0      0      MN1      W=    5.40u L=1.0u
MN4916   #2144    #1990    0      0      MN1      W=    5.40u L=1.0u
MN4915   #2142    #1988    0      0      MN1      W=    5.40u L=1.0u
MN4914   #2140    #1986    0      0      MN1      W=    5.40u L=1.0u
MN4913   #2155    #1756    0      0      MN1      W=    5.40u L=1.0u
MP4912   #2138    #1982    #2171    1      MP1      W=    5.40u L=1.0u
MP4911   #2136    #1853    #2170    1      MP1      W=    5.40u L=1.0u
MP4910   #2135    #1755    #2169    1      MP1      W=    5.40u L=1.0u
MP4909   #2134    #1762    #2168    1      MP1      W=    5.40u L=1.0u
MP4908   #2133    #1754    #2167    1      MP1      W=    5.40u L=1.0u
MP4907   #2132    #1761    #2166    1      MP1      W=    5.40u L=1.0u
MP4906   #2131    #1753    #2165    1      MP1      W=    5.40u L=1.0u
MP4905   #2130    #1760    #2164    1      MP1      W=    5.40u L=1.0u
MP4904   #2129    #1752    #2163    1      MP1      W=    5.40u L=1.0u
MP4903   #2128    #1759    #2162    1      MP1      W=    5.40u L=1.0u
MP4902   #2127    #1751    #2161    1      MP1      W=    5.40u L=1.0u
MP4901   #2126    #1758    #2160    1      MP1      W=    5.40u L=1.0u
MP4900   #2125    #1750    #2159    1      MP1      W=    5.40u L=1.0u
MP4899   #2124    #1757    #2158    1      MP1      W=    5.40u L=1.0u
MP4898   #2123    #1749    #2157    1      MP1      W=    5.40u L=1.0u
MP4897   #2122    #1851    #2156    1      MP1      W=    5.40u L=1.0u
MN4896   #2137    #1982    #2155    0      MN1      W=    5.40u L=1.0u
MN4895   #2106    #2088    #2154    0      MN1      W=    1.80u L=1.0u
MN4894   #2121    #1755    #2153    0      MN1      W=    5.40u L=1.0u
MN4893   #2120    #1762    #2152    0      MN1      W=    5.40u L=1.0u
MN4892   #2119    #1754    #2151    0      MN1      W=    5.40u L=1.0u
MN4891   #2118    #1761    #2150    0      MN1      W=    5.40u L=1.0u
MN4890   #2117    #1753    #2149    0      MN1      W=    5.40u L=1.0u
MN4889   #2116    #1760    #2148    0      MN1      W=    5.40u L=1.0u
MN4888   #2115    #1752    #2147    0      MN1      W=    5.40u L=1.0u
MN4887   #2114    #1759    #2146    0      MN1      W=    5.40u L=1.0u
MN4886   #2113    #1751    #2145    0      MN1      W=    5.40u L=1.0u
MN4885   #2112    #1758    #2144    0      MN1      W=    5.40u L=1.0u
MN4884   #2111    #1750    #2143    0      MN1      W=    5.40u L=1.0u
MN4883   #2110    #1757    #2142    0      MN1      W=    5.40u L=1.0u
MN4882   #2109    #1749    #2141    0      MN1      W=    5.40u L=1.0u
MN4881   #2108    #1851    #2140    0      MN1      W=    5.40u L=1.0u
MN4880   #2107    #1853    #2139    0      MN1      W=    5.40u L=1.0u
MP4879   1      #2088    #2106    1      MP1      W=    1.80u L=1.0u
MN4878   Z22      #2088    #2137    0      MN1      W=    5.40u L=1.0u
MP4877   Z22      #2088    #2138    1      MP1      W=    5.40u L=1.0u
MP4876   #2091    #1852    #2136    1      MP1      W=    1.80u L=1.0u
MN4875   #2098    #2017    #2121    0      MN1      W=    1.80u L=1.0u
MP4874   #2098    #2017    #2135    1      MP1      W=    1.80u L=1.0u
MP4873   #2105    #2016    #2134    1      MP1      W=    1.80u L=1.0u
MN4872   #2105    #2016    #2120    0      MN1      W=    1.80u L=1.0u
MN4871   #2097    #2015    #2119    0      MN1      W=    1.80u L=1.0u
MP4870   #2097    #2015    #2133    1      MP1      W=    1.80u L=1.0u
MP4869   #2104    #2014    #2132    1      MP1      W=    1.80u L=1.0u
MN4868   #2104    #2014    #2118    0      MN1      W=    1.80u L=1.0u
MN4867   #2096    #2013    #2117    0      MN1      W=    1.80u L=1.0u
MP4866   #2096    #2013    #2131    1      MP1      W=    1.80u L=1.0u
MP4865   #2103    #2012    #2130    1      MP1      W=    1.80u L=1.0u
MN4864   #2103    #2012    #2116    0      MN1      W=    1.80u L=1.0u
MN4863   #2095    #2011    #2115    0      MN1      W=    1.80u L=1.0u
MP4862   #2095    #2011    #2129    1      MP1      W=    1.80u L=1.0u
MP4861   #2102    #2010    #2128    1      MP1      W=    1.80u L=1.0u
MN4860   #2102    #2010    #2114    0      MN1      W=    1.80u L=1.0u
MN4859   #2094    #2009    #2113    0      MN1      W=    1.80u L=1.0u
MP4858   #2094    #2009    #2127    1      MP1      W=    1.80u L=1.0u
MP4857   #2101    #2008    #2126    1      MP1      W=    1.80u L=1.0u
MN4856   #2101    #2008    #2112    0      MN1      W=    1.80u L=1.0u
MN4855   #2093    #2007    #2111    0      MN1      W=    1.80u L=1.0u
MP4854   #2093    #2007    #2125    1      MP1      W=    1.80u L=1.0u
MP4853   #2100    #2006    #2124    1      MP1      W=    1.80u L=1.0u
MN4852   #2100    #2006    #2110    0      MN1      W=    1.80u L=1.0u
MN4851   #2092    #2005    #2109    0      MN1      W=    1.80u L=1.0u
MP4850   #2092    #2005    #2123    1      MP1      W=    1.80u L=1.0u
MP4849   #2099    #2004    #2122    1      MP1      W=    1.80u L=1.0u
MN4848   #2099    #2004    #2108    0      MN1      W=    1.80u L=1.0u
MN4847   #2091    #1852    #2107    0      MN1      W=    1.80u L=1.0u
MP4846   #2055    #2056    Z22      1      MP1      W=    1.80u L=1.0u
MP4845   #2088    #2018    1      1      MP1      W=    1.80u L=1.0u
MN4844   #2054    #2056    Z22      0      MN1      W=    1.80u L=1.0u
MN4843   #2070    #2017    #2105    0      MN1      W=    1.80u L=1.0u
MN4842   #2068    #2015    #2104    0      MN1      W=    1.80u L=1.0u
MN4841   #2066    #2013    #2103    0      MN1      W=    1.80u L=1.0u
MN4840   #2064    #2011    #2102    0      MN1      W=    1.80u L=1.0u
MN4839   #2062    #2009    #2101    0      MN1      W=    1.80u L=1.0u
MN4838   #2060    #2007    #2100    0      MN1      W=    1.80u L=1.0u
MN4837   #2058    #2005    #2099    0      MN1      W=    1.80u L=1.0u
MP4836   #2086    #2004    #2091    1      MP1      W=    1.80u L=1.0u
MP4835   #2085    #1940    #2098    1      MP1      W=    1.80u L=1.0u
MP4834   #2084    #2017    #2105    1      MP1      W=    1.80u L=1.0u
MP4833   #2083    #2016    #2097    1      MP1      W=    1.80u L=1.0u
MP4832   #2082    #2015    #2104    1      MP1      W=    1.80u L=1.0u
MP4831   #2081    #2014    #2096    1      MP1      W=    1.80u L=1.0u
MP4830   #2080    #2013    #2103    1      MP1      W=    1.80u L=1.0u
MP4829   #2079    #2012    #2095    1      MP1      W=    1.80u L=1.0u
MP4828   #2078    #2011    #2102    1      MP1      W=    1.80u L=1.0u
MP4827   #2077    #2010    #2094    1      MP1      W=    1.80u L=1.0u
MP4826   #2076    #2009    #2101    1      MP1      W=    1.80u L=1.0u
MP4825   #2075    #2008    #2093    1      MP1      W=    1.80u L=1.0u
MP4824   #2074    #2007    #2100    1      MP1      W=    1.80u L=1.0u
MP4823   #2073    #2006    #2092    1      MP1      W=    1.80u L=1.0u
MP4822   #2072    #2005    #2099    1      MP1      W=    1.80u L=1.0u
MN4821   #2071    #1940    #2098    0      MN1      W=    1.80u L=1.0u
MN4820   #2069    #2016    #2097    0      MN1      W=    1.80u L=1.0u
MN4819   #2067    #2014    #2096    0      MN1      W=    1.80u L=1.0u
MN4818   #2065    #2012    #2095    0      MN1      W=    1.80u L=1.0u
MN4817   #2063    #2010    #2094    0      MN1      W=    1.80u L=1.0u
MN4816   #2061    #2008    #2093    0      MN1      W=    1.80u L=1.0u
MN4815   #2059    #2006    #2092    0      MN1      W=    1.80u L=1.0u
MN4814   #2057    #2004    #2091    0      MN1      W=    1.80u L=1.0u
MP4813   #2087    X5       1      1      MP1      W=   10.80u L=1.0u
MN4812   #2090    X5       #2087    0      MN1      W=    3.60u L=1.0u
MN4811   #2089    #2018    #2088    0      MN1      W=    1.80u L=1.0u
MN4810   0      #2016    #2070    0      MN1      W=    1.80u L=1.0u
MN4809   0      #2014    #2068    0      MN1      W=    1.80u L=1.0u
MN4808   0      #2012    #2066    0      MN1      W=    1.80u L=1.0u
MN4807   0      #2010    #2064    0      MN1      W=    1.80u L=1.0u
MN4806   0      #2008    #2062    0      MN1      W=    1.80u L=1.0u
MN4805   0      #2006    #2060    0      MN1      W=    1.80u L=1.0u
MN4804   0      #2004    #2058    0      MN1      W=    1.80u L=1.0u
MP4803   1      #1852    #2086    1      MP1      W=    1.80u L=1.0u
MN4802   0      #2017    #2071    0      MN1      W=    1.80u L=1.0u
MP4801   1      #2017    #2085    1      MP1      W=    1.80u L=1.0u
MP4800   1      #2016    #2084    1      MP1      W=    1.80u L=1.0u
MN4799   0      #2015    #2069    0      MN1      W=    1.80u L=1.0u
MP4798   1      #2015    #2083    1      MP1      W=    1.80u L=1.0u
MP4797   1      #2014    #2082    1      MP1      W=    1.80u L=1.0u
MN4796   0      #2013    #2067    0      MN1      W=    1.80u L=1.0u
MP4795   1      #2013    #2081    1      MP1      W=    1.80u L=1.0u
MP4794   1      #2012    #2080    1      MP1      W=    1.80u L=1.0u
MN4793   0      #2011    #2065    0      MN1      W=    1.80u L=1.0u
MP4792   1      #2011    #2079    1      MP1      W=    1.80u L=1.0u
MP4791   1      #2010    #2078    1      MP1      W=    1.80u L=1.0u
MN4790   0      #2009    #2063    0      MN1      W=    1.80u L=1.0u
MP4789   1      #2009    #2077    1      MP1      W=    1.80u L=1.0u
MP4788   1      #2008    #2076    1      MP1      W=    1.80u L=1.0u
MN4787   0      #2007    #2061    0      MN1      W=    1.80u L=1.0u
MP4786   1      #2007    #2075    1      MP1      W=    1.80u L=1.0u
MP4785   1      #2006    #2074    1      MP1      W=    1.80u L=1.0u
MN4784   0      #2005    #2059    0      MN1      W=    1.80u L=1.0u
MP4783   1      #2005    #2073    1      MP1      W=    1.80u L=1.0u
MP4782   1      #2004    #2072    1      MP1      W=    1.80u L=1.0u
MN4781   0      #1852    #2057    0      MN1      W=    1.80u L=1.0u
MN4780   0      #2088    #2054    0      MN1      W=    5.40u L=1.0u
MP4779   1      #2088    #2055    1      MP1      W=    5.40u L=1.0u
MP4778   1      X6       #2087    1      MP1      W=   10.80u L=1.0u
MP4777   1      #2019    #2088    1      MP1      W=    1.80u L=1.0u
MN4776   0      X6       #2090    0      MN1      W=    3.60u L=1.0u
MN4775   0      #2019    #2089    0      MN1      W=    1.80u L=1.0u
MP4774   #2086    #1853    1      1      MP1      W=    5.40u L=1.0u
MP4773   #2085    #1755    1      1      MP1      W=    5.40u L=1.0u
MP4772   #2084    #1762    1      1      MP1      W=    5.40u L=1.0u
MP4771   #2083    #1754    1      1      MP1      W=    5.40u L=1.0u
MP4770   #2082    #1761    1      1      MP1      W=    5.40u L=1.0u
MP4769   #2081    #1753    1      1      MP1      W=    5.40u L=1.0u
MP4768   #2080    #1760    1      1      MP1      W=    5.40u L=1.0u
MP4767   #2079    #1752    1      1      MP1      W=    5.40u L=1.0u
MP4766   #2078    #1759    1      1      MP1      W=    5.40u L=1.0u
MP4765   #2077    #1751    1      1      MP1      W=    5.40u L=1.0u
MP4764   #2076    #1758    1      1      MP1      W=    5.40u L=1.0u
MP4763   #2075    #1750    1      1      MP1      W=    5.40u L=1.0u
MP4762   #2074    #1757    1      1      MP1      W=    5.40u L=1.0u
MP4761   #2073    #1749    1      1      MP1      W=    5.40u L=1.0u
MP4760   #2072    #1851    1      1      MP1      W=    5.40u L=1.0u
MN4759   #2071    #1755    0      0      MN1      W=    5.40u L=1.0u
MN4758   #2070    #1762    0      0      MN1      W=    5.40u L=1.0u
MN4757   #2069    #1754    0      0      MN1      W=    5.40u L=1.0u
MN4756   #2068    #1761    0      0      MN1      W=    5.40u L=1.0u
MN4755   #2067    #1753    0      0      MN1      W=    5.40u L=1.0u
MN4754   #2066    #1760    0      0      MN1      W=    5.40u L=1.0u
MN4753   #2065    #1752    0      0      MN1      W=    5.40u L=1.0u
MN4752   #2064    #1759    0      0      MN1      W=    5.40u L=1.0u
MN4751   #2063    #1751    0      0      MN1      W=    5.40u L=1.0u
MN4750   #2062    #1758    0      0      MN1      W=    5.40u L=1.0u
MN4749   #2061    #1750    0      0      MN1      W=    5.40u L=1.0u
MN4748   #2060    #1757    0      0      MN1      W=    5.40u L=1.0u
MN4747   #2059    #1749    0      0      MN1      W=    5.40u L=1.0u
MN4746   #2058    #1851    0      0      MN1      W=    5.40u L=1.0u
MN4745   #2057    #1853    0      0      MN1      W=    5.40u L=1.0u
MN4744   #2021    #2087    0      0      MN1      W=    3.60u L=1.0u
MN4743   #2056    #1558    0      0      MN1      W=    1.80u L=1.0u
MP4742   #1764    #2087    1      1      MP1      W=   10.80u L=1.0u
MP4741   #2055    #1756    1      1      MP1      W=    5.40u L=1.0u
MP4740   #2056    #1558    1      1      MP1      W=    1.80u L=1.0u
MN4739   #2054    #1756    0      0      MN1      W=    5.40u L=1.0u
MP4738   1      #1985    #2086    1      MP1      W=    5.40u L=1.0u
MN4737   0      #1999    #2071    0      MN1      W=    5.40u L=1.0u
MP4736   1      #1999    #2085    1      MP1      W=    5.40u L=1.0u
MP4735   1      #1998    #2084    1      MP1      W=    5.40u L=1.0u
MN4734   0      #1998    #2070    0      MN1      W=    5.40u L=1.0u
MN4733   0      #1997    #2069    0      MN1      W=    5.40u L=1.0u
MP4732   1      #1997    #2083    1      MP1      W=    5.40u L=1.0u
MP4731   1      #1996    #2082    1      MP1      W=    5.40u L=1.0u
MN4730   0      #1996    #2068    0      MN1      W=    5.40u L=1.0u
MN4729   0      #1995    #2067    0      MN1      W=    5.40u L=1.0u
MP4728   1      #1995    #2081    1      MP1      W=    5.40u L=1.0u
MP4727   1      #1994    #2080    1      MP1      W=    5.40u L=1.0u
MN4726   0      #1994    #2066    0      MN1      W=    5.40u L=1.0u
MN4725   0      #1993    #2065    0      MN1      W=    5.40u L=1.0u
MP4724   1      #1993    #2079    1      MP1      W=    5.40u L=1.0u
MP4723   1      #1992    #2078    1      MP1      W=    5.40u L=1.0u
MN4722   0      #1992    #2064    0      MN1      W=    5.40u L=1.0u
MN4721   0      #1991    #2063    0      MN1      W=    5.40u L=1.0u
MP4720   1      #1991    #2077    1      MP1      W=    5.40u L=1.0u
MP4719   1      #1990    #2076    1      MP1      W=    5.40u L=1.0u
MN4718   0      #1990    #2062    0      MN1      W=    5.40u L=1.0u
MN4717   0      #1989    #2061    0      MN1      W=    5.40u L=1.0u
MP4716   1      #1989    #2075    1      MP1      W=    5.40u L=1.0u
MP4715   1      #1988    #2074    1      MP1      W=    5.40u L=1.0u
MN4714   0      #1988    #2060    0      MN1      W=    5.40u L=1.0u
MN4713   0      #1987    #2059    0      MN1      W=    5.40u L=1.0u
MP4712   1      #1987    #2073    1      MP1      W=    5.40u L=1.0u
MP4711   1      #1986    #2072    1      MP1      W=    5.40u L=1.0u
MN4710   0      #1986    #2058    0      MN1      W=    5.40u L=1.0u
MN4709   0      #1985    #2057    0      MN1      W=    5.40u L=1.0u
MN4708   #1764    X6       #2021    0      MN1      W=    3.60u L=1.0u
MP4707   #2053    X6       #1764    1      MP1      W=   10.80u L=1.0u
MP4706   1      #1982    #2055    1      MP1      W=    5.40u L=1.0u
MN4705   0      #1982    #2054    0      MN1      W=    5.40u L=1.0u
MP4704   #2037    #1985    1      1      MP1      W=    5.40u L=1.0u
MP4703   #2051    #1999    1      1      MP1      W=    5.40u L=1.0u
MP4702   #2050    #1998    1      1      MP1      W=    5.40u L=1.0u
MP4701   #2049    #1997    1      1      MP1      W=    5.40u L=1.0u
MP4700   #2048    #1996    1      1      MP1      W=    5.40u L=1.0u
MP4699   #2047    #1995    1      1      MP1      W=    5.40u L=1.0u
MP4698   #2046    #1994    1      1      MP1      W=    5.40u L=1.0u
MP4697   #2045    #1993    1      1      MP1      W=    5.40u L=1.0u
MP4696   #2044    #1992    1      1      MP1      W=    5.40u L=1.0u
MP4695   #2043    #1991    1      1      MP1      W=    5.40u L=1.0u
MP4694   #2042    #1990    1      1      MP1      W=    5.40u L=1.0u
MP4693   #2041    #1989    1      1      MP1      W=    5.40u L=1.0u
MP4692   #2040    #1988    1      1      MP1      W=    5.40u L=1.0u
MP4691   #2039    #1987    1      1      MP1      W=    5.40u L=1.0u
MP4690   #2038    #1986    1      1      MP1      W=    5.40u L=1.0u
MN4689   #2036    #1999    0      0      MN1      W=    5.40u L=1.0u
MN4688   #2035    #1998    0      0      MN1      W=    5.40u L=1.0u
MN4687   #2034    #1997    0      0      MN1      W=    5.40u L=1.0u
MN4686   #2033    #1996    0      0      MN1      W=    5.40u L=1.0u
MN4685   #2032    #1995    0      0      MN1      W=    5.40u L=1.0u
MN4684   #2031    #1994    0      0      MN1      W=    5.40u L=1.0u
MN4683   #2030    #1993    0      0      MN1      W=    5.40u L=1.0u
MN4682   #2029    #1992    0      0      MN1      W=    5.40u L=1.0u
MN4681   #2028    #1991    0      0      MN1      W=    5.40u L=1.0u
MN4680   #2027    #1990    0      0      MN1      W=    5.40u L=1.0u
MN4679   #2026    #1989    0      0      MN1      W=    5.40u L=1.0u
MN4678   #2025    #1988    0      0      MN1      W=    5.40u L=1.0u
MN4677   #2024    #1987    0      0      MN1      W=    5.40u L=1.0u
MN4676   #2023    #1986    0      0      MN1      W=    5.40u L=1.0u
MP4675   1      X5       #2053    1      MP1      W=   10.80u L=1.0u
MN4674   #2022    #1985    0      0      MN1      W=    5.40u L=1.0u
MN4673   #2021    X5       #1764    0      MN1      W=    3.60u L=1.0u
MN4672   #1558    #1980    0      0      MN1      W=    1.80u L=1.0u
MP4671   #2002    #1980    1      1      MP1      W=    5.40u L=1.0u
MP4670   #2019    #1942    1      1      MP1      W=    5.40u L=1.0u
MN4669   #2020    #1942    #2019    0      MN1      W=    5.40u L=1.0u
MP4668   #1940    #1755    #2051    1      MP1      W=    5.40u L=1.0u
MP4667   #2017    #1762    #2050    1      MP1      W=    5.40u L=1.0u
MP4666   #2016    #1754    #2049    1      MP1      W=    5.40u L=1.0u
MP4665   #2015    #1761    #2048    1      MP1      W=    5.40u L=1.0u
MP4664   #2014    #1753    #2047    1      MP1      W=    5.40u L=1.0u
MP4663   #2013    #1760    #2046    1      MP1      W=    5.40u L=1.0u
MP4662   #2012    #1752    #2045    1      MP1      W=    5.40u L=1.0u
MP4661   #2011    #1759    #2044    1      MP1      W=    5.40u L=1.0u
MP4660   #2010    #1751    #2043    1      MP1      W=    5.40u L=1.0u
MP4659   #2009    #1758    #2042    1      MP1      W=    5.40u L=1.0u
MP4658   #2008    #1750    #2041    1      MP1      W=    5.40u L=1.0u
MP4657   #2007    #1757    #2040    1      MP1      W=    5.40u L=1.0u
MP4656   #2006    #1749    #2039    1      MP1      W=    5.40u L=1.0u
MP4655   #2005    #1851    #2038    1      MP1      W=    5.40u L=1.0u
MP4654   #2004    #1853    #2037    1      MP1      W=    5.40u L=1.0u
MN4653   #1940    #1755    #2036    0      MN1      W=    5.40u L=1.0u
MN4652   #2017    #1762    #2035    0      MN1      W=    5.40u L=1.0u
MN4651   #2016    #1754    #2034    0      MN1      W=    5.40u L=1.0u
MN4650   #2015    #1761    #2033    0      MN1      W=    5.40u L=1.0u
MN4649   #2014    #1753    #2032    0      MN1      W=    5.40u L=1.0u
MN4648   #2013    #1760    #2031    0      MN1      W=    5.40u L=1.0u
MN4647   #2012    #1752    #2030    0      MN1      W=    5.40u L=1.0u
MN4646   #2011    #1759    #2029    0      MN1      W=    5.40u L=1.0u
MN4645   #2010    #1751    #2028    0      MN1      W=    5.40u L=1.0u
MN4644   #2009    #1758    #2027    0      MN1      W=    5.40u L=1.0u
MN4643   #2008    #1750    #2026    0      MN1      W=    5.40u L=1.0u
MN4642   #2007    #1757    #2025    0      MN1      W=    5.40u L=1.0u
MN4641   #2006    #1749    #2024    0      MN1      W=    5.40u L=1.0u
MN4640   #2005    #1851    #2023    0      MN1      W=    5.40u L=1.0u
MN4639   #2004    #1853    #2022    0      MN1      W=    5.40u L=1.0u
MP4638   #1984    X7       1      1      MP1      W=   10.80u L=1.0u
MN4637   0      #2000    #2020    0      MN1      W=    5.40u L=1.0u
MP4636   #1558    #2018    #2002    1      MP1      W=    5.40u L=1.0u
MP4635   1      #2000    #2019    1      MP1      W=    5.40u L=1.0u
MN4634   #2003    #2018    #1558    0      MN1      W=    5.40u L=1.0u
MP4633   #1974    #2017    #1940    1      MP1      W=    5.40u L=1.0u
MP4632   #1973    #2016    #2017    1      MP1      W=    5.40u L=1.0u
MP4631   #1972    #2015    #2016    1      MP1      W=    5.40u L=1.0u
MP4630   #1971    #2014    #2015    1      MP1      W=    5.40u L=1.0u
MP4629   #1970    #2013    #2014    1      MP1      W=    5.40u L=1.0u
MP4628   #1969    #2012    #2013    1      MP1      W=    5.40u L=1.0u
MP4627   #1968    #2011    #2012    1      MP1      W=    5.40u L=1.0u
MP4626   #1967    #2010    #2011    1      MP1      W=    5.40u L=1.0u
MP4625   #1966    #2009    #2010    1      MP1      W=    5.40u L=1.0u
MP4624   #1965    #2008    #2009    1      MP1      W=    5.40u L=1.0u
MP4623   #1964    #2007    #2008    1      MP1      W=    5.40u L=1.0u
MP4622   #1963    #2006    #2007    1      MP1      W=    5.40u L=1.0u
MP4621   #1962    #2005    #2006    1      MP1      W=    5.40u L=1.0u
MP4620   #1961    #2004    #2005    1      MP1      W=    5.40u L=1.0u
MP4619   #1960    #1852    #2004    1      MP1      W=    5.40u L=1.0u
MN4618   #1959    #2017    #1940    0      MN1      W=    5.40u L=1.0u
MN4617   #1958    #2016    #2017    0      MN1      W=    5.40u L=1.0u
MN4616   #1957    #2015    #2016    0      MN1      W=    5.40u L=1.0u
MN4615   #1956    #2014    #2015    0      MN1      W=    5.40u L=1.0u
MN4614   #1955    #2013    #2014    0      MN1      W=    5.40u L=1.0u
MN4613   #1954    #2012    #2013    0      MN1      W=    5.40u L=1.0u
MN4612   #1953    #2011    #2012    0      MN1      W=    5.40u L=1.0u
MN4611   #1952    #2010    #2011    0      MN1      W=    5.40u L=1.0u
MN4610   #1951    #2009    #2010    0      MN1      W=    5.40u L=1.0u
MN4609   #1950    #2008    #2009    0      MN1      W=    5.40u L=1.0u
MN4608   #1949    #2007    #2008    0      MN1      W=    5.40u L=1.0u
MN4607   #1948    #2006    #2007    0      MN1      W=    5.40u L=1.0u
MN4606   #1947    #2005    #2006    0      MN1      W=    5.40u L=1.0u
MN4605   #1946    #2004    #2005    0      MN1      W=    5.40u L=1.0u
MN4604   #1945    #1852    #2004    0      MN1      W=    5.40u L=1.0u
MP4603   1      X6       #1984    1      MP1      W=   10.80u L=1.0u
MN4602   #2001    X6       #1984    0      MN1      W=    3.60u L=1.0u
MN4601   #2000    #1982    0      0      MN1      W=    5.40u L=1.0u
MN4600   0      #1943    #2003    0      MN1      W=    5.40u L=1.0u
MP4599   #2002    #1943    #1558    1      MP1      W=    1.80u L=1.0u
MP4598   #2000    #1982    1      1      MP1      W=    5.40u L=1.0u
MN4597   0      #1999    #1959    0      MN1      W=   16.20u L=1.0u
MP4596   1      #1999    #1974    1      MP1      W=   16.20u L=1.0u
MP4595   1      #1998    #1973    1      MP1      W=   16.20u L=1.0u
MN4594   0      #1998    #1958    0      MN1      W=   16.20u L=1.0u
MN4593   0      #1997    #1957    0      MN1      W=   16.20u L=1.0u
MP4592   1      #1997    #1972    1      MP1      W=   16.20u L=1.0u
MP4591   1      #1996    #1971    1      MP1      W=   16.20u L=1.0u
MN4590   0      #1996    #1956    0      MN1      W=   16.20u L=1.0u
MN4589   0      #1995    #1955    0      MN1      W=   16.20u L=1.0u
MP4588   1      #1995    #1970    1      MP1      W=   16.20u L=1.0u
MP4587   1      #1994    #1969    1      MP1      W=   16.20u L=1.0u
MN4586   0      #1994    #1954    0      MN1      W=   16.20u L=1.0u
MN4585   0      #1993    #1953    0      MN1      W=   16.20u L=1.0u
MP4584   1      #1993    #1968    1      MP1      W=   16.20u L=1.0u
MP4583   1      #1992    #1967    1      MP1      W=   16.20u L=1.0u
MN4582   0      #1992    #1952    0      MN1      W=   16.20u L=1.0u
MN4581   0      #1991    #1951    0      MN1      W=   16.20u L=1.0u
MP4580   1      #1991    #1966    1      MP1      W=   16.20u L=1.0u
MP4579   1      #1990    #1965    1      MP1      W=   16.20u L=1.0u
MN4578   0      #1990    #1950    0      MN1      W=   16.20u L=1.0u
MN4577   0      #1989    #1949    0      MN1      W=   16.20u L=1.0u
MP4576   1      #1989    #1964    1      MP1      W=   16.20u L=1.0u
MP4575   1      #1988    #1963    1      MP1      W=   16.20u L=1.0u
MN4574   0      #1988    #1948    0      MN1      W=   16.20u L=1.0u
MN4573   0      #1987    #1947    0      MN1      W=   16.20u L=1.0u
MP4572   1      #1987    #1962    1      MP1      W=   16.20u L=1.0u
MP4571   1      #1986    #1961    1      MP1      W=   16.20u L=1.0u
MN4570   0      #1986    #1946    0      MN1      W=   16.20u L=1.0u
MN4569   0      #1985    #1945    0      MN1      W=   16.20u L=1.0u
MP4568   1      #1985    #1960    1      MP1      W=   16.20u L=1.0u
MN4567   0      X7       #2001    0      MN1      W=    3.60u L=1.0u
MN4536   #1980    #1982    0      0      MN1      W=    5.40u L=1.0u
MN4535   #1982    #1940    0      0      MN1      W=    5.40u L=1.0u
MP4534   #1983    #1940    #1982    1      MP1      W=    5.40u L=1.0u
MP4518   1      #1984    #1833    1      MP1      W=   10.80u L=1.0u
MP4517   #1981    #1982    #1980    1      MP1      W=    5.40u L=1.0u
MN4501   #1979    #1984    0      0      MN1      W=    3.60u L=1.0u
MP4500   1      #1763    #1983    1      MP1      W=    5.40u L=1.0u
MN4499   0      #1763    #1982    0      MN1      W=    5.40u L=1.0u
MP4498   1      #1756    #1981    1      MP1      W=    5.40u L=1.0u
MN4497   0      #1756    #1980    0      MN1      W=    5.40u L=1.0u
MN4496   #1941    #1764    #1979    0      MN1      W=    3.60u L=1.0u
MP4495   #1833    #1764    1      1      MP1      W=   10.80u L=1.0u
MN4494   #1975    #1763    0      0      MN1      W=    5.40u L=1.0u
MN4493   #1959    #1755    0      0      MN1      W=   10.80u L=1.0u
MN4492   #1958    #1762    0      0      MN1      W=   10.80u L=1.0u
MN4491   #1957    #1754    0      0      MN1      W=   10.80u L=1.0u
MN4490   #1956    #1761    0      0      MN1      W=   10.80u L=1.0u
MN4489   #1955    #1753    0      0      MN1      W=   10.80u L=1.0u
MN4488   #1954    #1760    0      0      MN1      W=   10.80u L=1.0u
MN4487   #1953    #1752    0      0      MN1      W=   10.80u L=1.0u
MN4486   #1952    #1759    0      0      MN1      W=   10.80u L=1.0u
MN4485   #1951    #1751    0      0      MN1      W=   10.80u L=1.0u
MN4484   #1950    #1758    0      0      MN1      W=   10.80u L=1.0u
MN4483   #1949    #1750    0      0      MN1      W=   10.80u L=1.0u
MN4482   #1948    #1757    0      0      MN1      W=   10.80u L=1.0u
MN4481   #1947    #1749    0      0      MN1      W=   10.80u L=1.0u
MN4480   #1946    #1851    0      0      MN1      W=   10.80u L=1.0u
MN4479   #1945    #1853    0      0      MN1      W=   10.80u L=1.0u
MP4478   #1942    #1763    1      1      MP1      W=    5.40u L=1.0u
MP4477   #1974    #1755    1      1      MP1      W=   10.80u L=1.0u
MP4476   #1973    #1762    1      1      MP1      W=   10.80u L=1.0u
MP4475   #1972    #1754    1      1      MP1      W=   10.80u L=1.0u
MP4474   #1971    #1761    1      1      MP1      W=   10.80u L=1.0u
MP4473   #1970    #1753    1      1      MP1      W=   10.80u L=1.0u
MP4472   #1969    #1760    1      1      MP1      W=   10.80u L=1.0u
MP4471   #1968    #1752    1      1      MP1      W=   10.80u L=1.0u
MP4470   #1967    #1759    1      1      MP1      W=   10.80u L=1.0u
MP4469   #1966    #1751    1      1      MP1      W=   10.80u L=1.0u
MP4468   #1965    #1758    1      1      MP1      W=   10.80u L=1.0u
MP4467   #1964    #1750    1      1      MP1      W=   10.80u L=1.0u
MP4466   #1963    #1757    1      1      MP1      W=   10.80u L=1.0u
MP4465   #1962    #1749    1      1      MP1      W=   10.80u L=1.0u
MP4464   #1961    #1851    1      1      MP1      W=   10.80u L=1.0u
MP4463   #1960    #1853    1      1      MP1      W=   10.80u L=1.0u
MP4462   #1943    #1942    1      1      MP1      W=    5.40u L=1.0u
MN4461   #1977    #1942    0      0      MN1      W=    5.40u L=1.0u
MN4460   #1833    X6       #1941    0      MN1      W=    3.60u L=1.0u
MP4459   #1976    X6       #1833    1      MP1      W=   10.80u L=1.0u
MN4458   #1943    #1756    #1977    0      MN1      W=    5.40u L=1.0u
MP4457   1      #1756    #1943    1      MP1      W=    5.40u L=1.0u
MN4456   #1942    #1940    #1975    0      MN1      W=    5.40u L=1.0u
MP4455   1      X7       #1976    1      MP1      W=   10.80u L=1.0u
MP4454   1      #1940    #1942    1      MP1      W=    5.40u L=1.0u
MN4423   #1941    X7       #1833    0      MN1      W=    3.60u L=1.0u
MN4422   0      #1798    #1870    0      MN1      W=    3.60u L=1.0u
MN4421   0      #1799    #1861    0      MN1      W=    3.60u L=1.0u
MN4420   0      #1814    #1869    0      MN1      W=    3.60u L=1.0u
MN4419   0      #1813    #1860    0      MN1      W=    3.60u L=1.0u
MN4418   0      #1812    #1868    0      MN1      W=    3.60u L=1.0u
MN4417   0      #1811    #1859    0      MN1      W=    3.60u L=1.0u
MN4416   0      #1810    #1867    0      MN1      W=    3.60u L=1.0u
MN4415   0      #1809    #1858    0      MN1      W=    3.60u L=1.0u
MN4414   0      #1808    #1866    0      MN1      W=    3.60u L=1.0u
MN4413   0      #1807    #1857    0      MN1      W=    3.60u L=1.0u
MN4412   0      #1806    #1865    0      MN1      W=    3.60u L=1.0u
MN4411   0      #1805    #1856    0      MN1      W=    3.60u L=1.0u
MN4410   0      #1804    #1864    0      MN1      W=    3.60u L=1.0u
MN4409   0      #1803    #1855    0      MN1      W=    3.60u L=1.0u
MN4408   0      #1802    #1863    0      MN1      W=    3.60u L=1.0u
MP4407   1      #1798    #1870    1      MP1      W=    3.60u L=1.0u
MP4406   1      #1799    #1861    1      MP1      W=    3.60u L=1.0u
MP4405   1      #1814    #1869    1      MP1      W=    3.60u L=1.0u
MP4404   1      #1813    #1860    1      MP1      W=    3.60u L=1.0u
MP4403   1      #1812    #1868    1      MP1      W=    3.60u L=1.0u
MP4402   1      #1811    #1859    1      MP1      W=    3.60u L=1.0u
MP4401   1      #1810    #1867    1      MP1      W=    3.60u L=1.0u
MP4400   1      #1809    #1858    1      MP1      W=    3.60u L=1.0u
MP4399   1      #1808    #1866    1      MP1      W=    3.60u L=1.0u
MP4398   1      #1807    #1857    1      MP1      W=    3.60u L=1.0u
MP4397   1      #1806    #1865    1      MP1      W=    3.60u L=1.0u
MP4396   1      #1805    #1856    1      MP1      W=    3.60u L=1.0u
MP4395   1      #1804    #1864    1      MP1      W=    3.60u L=1.0u
MP4394   1      #1803    #1855    1      MP1      W=    3.60u L=1.0u
MP4393   1      #1802    #1863    1      MP1      W=    3.60u L=1.0u
MP4392   1      #1801    #1854    1      MP1      W=    3.60u L=1.0u
MN4391   0      #1801    #1854    0      MN1      W=    3.60u L=1.0u
MP4390   1      #1815    #1862    1      MP1      W=    3.60u L=1.0u
MP4389   #1905    #1853    1      1      MP1      W=   21.60u L=1.0u
MN4388   0      #1815    #1862    0      MN1      W=    3.60u L=1.0u
MN4387   #1905    #1853    0      0      MN1      W=    7.20u L=1.0u
MP4384   #1939    #1870    1      1      MP1      W=    3.60u L=1.0u
MP4383   #1938    #1861    1      1      MP1      W=    3.60u L=1.0u
MP4382   #1937    #1814    1      1      MP1      W=    3.60u L=1.0u
MP4381   #1936    #1860    1      1      MP1      W=    3.60u L=1.0u
MP4380   #1935    #1812    1      1      MP1      W=    3.60u L=1.0u
MP4379   #1934    #1859    1      1      MP1      W=    3.60u L=1.0u
MP4378   #1933    #1810    1      1      MP1      W=    3.60u L=1.0u
MP4377   #1932    #1858    1      1      MP1      W=    3.60u L=1.0u
MP4376   #1931    #1808    1      1      MP1      W=    3.60u L=1.0u
MP4375   #1930    #1857    1      1      MP1      W=    3.60u L=1.0u
MP4374   #1929    #1806    1      1      MP1      W=    3.60u L=1.0u
MP4373   #1928    #1856    1      1      MP1      W=    3.60u L=1.0u
MP4372   #1927    #1804    1      1      MP1      W=    3.60u L=1.0u
MP4371   #1926    #1855    1      1      MP1      W=    3.60u L=1.0u
MP4370   #1925    #1802    1      1      MP1      W=    3.60u L=1.0u
MP4369   #1924    #1854    1      1      MP1      W=    3.60u L=1.0u
MP4368   #1923    #1815    1      1      MP1      W=    3.60u L=1.0u
MN4367   #1922    #1798    0      0      MN1      W=    3.60u L=1.0u
MN4366   #1921    #1799    0      0      MN1      W=    3.60u L=1.0u
MN4365   #1920    #1869    0      0      MN1      W=    3.60u L=1.0u
MN4364   #1919    #1813    0      0      MN1      W=    3.60u L=1.0u
MN4363   #1918    #1868    0      0      MN1      W=    3.60u L=1.0u
MN4362   #1917    #1811    0      0      MN1      W=    3.60u L=1.0u
MN4361   #1916    #1867    0      0      MN1      W=    3.60u L=1.0u
MN4360   #1915    #1809    0      0      MN1      W=    3.60u L=1.0u
MN4359   #1914    #1866    0      0      MN1      W=    3.60u L=1.0u
MN4358   #1913    #1807    0      0      MN1      W=    3.60u L=1.0u
MN4357   #1912    #1865    0      0      MN1      W=    3.60u L=1.0u
MN4356   #1911    #1805    0      0      MN1      W=    3.60u L=1.0u
MN4355   #1910    #1864    0      0      MN1      W=    3.60u L=1.0u
MN4354   #1909    #1803    0      0      MN1      W=    3.60u L=1.0u
MN4353   #1908    #1863    0      0      MN1      W=    3.60u L=1.0u
MN4352   #1907    #1801    0      0      MN1      W=    3.60u L=1.0u
MN4351   #1906    #1862    0      0      MN1      W=    3.60u L=1.0u
MP4350   #1849    #1905    #1939    1      MP1      W=    3.60u L=1.0u
MP4349   #1848    #1905    #1938    1      MP1      W=    3.60u L=1.0u
MP4348   #1847    #1905    #1937    1      MP1      W=    3.60u L=1.0u
MP4347   #1846    #1905    #1936    1      MP1      W=    3.60u L=1.0u
MP4346   #1845    #1905    #1935    1      MP1      W=    3.60u L=1.0u
MP4345   #1844    #1905    #1934    1      MP1      W=    3.60u L=1.0u
MP4344   #1843    #1905    #1933    1      MP1      W=    3.60u L=1.0u
MP4343   #1842    #1905    #1932    1      MP1      W=    3.60u L=1.0u
MP4342   #1841    #1905    #1931    1      MP1      W=    3.60u L=1.0u
MP4341   #1840    #1905    #1930    1      MP1      W=    3.60u L=1.0u
MP4340   #1839    #1905    #1929    1      MP1      W=    3.60u L=1.0u
MP4339   #1838    #1905    #1928    1      MP1      W=    3.60u L=1.0u
MP4338   #1837    #1905    #1927    1      MP1      W=    3.60u L=1.0u
MP4337   #1836    #1905    #1926    1      MP1      W=    3.60u L=1.0u
MP4336   #1835    #1905    #1925    1      MP1      W=    3.60u L=1.0u
MP4335   #1834    #1905    #1924    1      MP1      W=    3.60u L=1.0u
MN4334   #1849    #1905    #1922    0      MN1      W=    3.60u L=1.0u
MN4333   #1848    #1905    #1921    0      MN1      W=    3.60u L=1.0u
MN4332   #1847    #1905    #1920    0      MN1      W=    3.60u L=1.0u
MN4331   #1846    #1905    #1919    0      MN1      W=    3.60u L=1.0u
MN4330   #1845    #1905    #1918    0      MN1      W=    3.60u L=1.0u
MN4329   #1844    #1905    #1917    0      MN1      W=    3.60u L=1.0u
MN4328   #1843    #1905    #1916    0      MN1      W=    3.60u L=1.0u
MN4327   #1842    #1905    #1915    0      MN1      W=    3.60u L=1.0u
MN4326   #1841    #1905    #1914    0      MN1      W=    3.60u L=1.0u
MN4325   #1840    #1905    #1913    0      MN1      W=    3.60u L=1.0u
MN4324   #1839    #1905    #1912    0      MN1      W=    3.60u L=1.0u
MN4323   #1838    #1905    #1911    0      MN1      W=    3.60u L=1.0u
MN4322   #1837    #1905    #1910    0      MN1      W=    3.60u L=1.0u
MN4321   #1836    #1905    #1909    0      MN1      W=    3.60u L=1.0u
MN4320   #1835    #1905    #1908    0      MN1      W=    3.60u L=1.0u
MN4319   #1834    #1905    #1907    0      MN1      W=    3.60u L=1.0u
MP4318   #1850    #1905    #1923    1      MP1      W=    3.60u L=1.0u
MN4317   #1850    #1905    #1906    0      MN1      W=    3.60u L=1.0u
MP4316   #1853    X7       1      1      MP1      W=   21.60u L=1.0u
MN4315   #1853    X7       0      0      MN1      W=    7.20u L=1.0u
MN4314   #1887    #1853    #1849    0      MN1      W=    3.60u L=1.0u
MP4313   #1904    #1853    #1849    1      MP1      W=    3.60u L=1.0u
MP4312   #1902    #1853    #1848    1      MP1      W=    3.60u L=1.0u
MN4311   #1885    #1853    #1847    0      MN1      W=    3.60u L=1.0u
MP4310   #1901    #1853    #1847    1      MP1      W=    3.60u L=1.0u
MP4309   #1900    #1853    #1846    1      MP1      W=    3.60u L=1.0u
MN4308   #1883    #1853    #1845    0      MN1      W=    3.60u L=1.0u
MP4307   #1899    #1853    #1845    1      MP1      W=    3.60u L=1.0u
MP4306   #1898    #1853    #1844    1      MP1      W=    3.60u L=1.0u
MN4305   #1881    #1853    #1843    0      MN1      W=    3.60u L=1.0u
MP4304   #1897    #1853    #1843    1      MP1      W=    3.60u L=1.0u
MP4303   #1896    #1853    #1842    1      MP1      W=    3.60u L=1.0u
MN4302   #1879    #1853    #1841    0      MN1      W=    3.60u L=1.0u
MP4301   #1895    #1853    #1841    1      MP1      W=    3.60u L=1.0u
MP4300   #1894    #1853    #1840    1      MP1      W=    3.60u L=1.0u
MN4299   #1877    #1853    #1839    0      MN1      W=    3.60u L=1.0u
MP4298   #1893    #1853    #1839    1      MP1      W=    3.60u L=1.0u
MP4297   #1892    #1853    #1838    1      MP1      W=    3.60u L=1.0u
MN4296   #1875    #1853    #1837    0      MN1      W=    3.60u L=1.0u
MP4295   #1891    #1853    #1837    1      MP1      W=    3.60u L=1.0u
MP4294   #1890    #1853    #1836    1      MP1      W=    3.60u L=1.0u
MN4293   #1873    #1853    #1835    0      MN1      W=    3.60u L=1.0u
MP4292   #1889    #1853    #1835    1      MP1      W=    3.60u L=1.0u
MP4291   #1888    #1853    #1834    1      MP1      W=    3.60u L=1.0u
MN4290   #1872    #1853    #1834    0      MN1      W=    3.60u L=1.0u
MN4289   #1886    #1853    #1848    0      MN1      W=    3.60u L=1.0u
MN4288   #1884    #1853    #1846    0      MN1      W=    3.60u L=1.0u
MN4287   #1882    #1853    #1844    0      MN1      W=    3.60u L=1.0u
MN4286   #1880    #1853    #1842    0      MN1      W=    3.60u L=1.0u
MN4285   #1878    #1853    #1840    0      MN1      W=    3.60u L=1.0u
MN4284   #1876    #1853    #1838    0      MN1      W=    3.60u L=1.0u
MN4283   #1874    #1853    #1836    0      MN1      W=    3.60u L=1.0u
MN4282   #1871    #1853    #1850    0      MN1      W=    3.60u L=1.0u
MP4281   #1903    #1853    #1850    1      MP1      W=    3.60u L=1.0u
MP4278   1      #1798    #1904    1      MP1      W=    3.60u L=1.0u
MP4277   1      #1862    #1903    1      MP1      W=    3.60u L=1.0u
MN4276   0      #1870    #1887    0      MN1      W=    3.60u L=1.0u
MP4275   1      #1799    #1902    1      MP1      W=    3.60u L=1.0u
MN4274   0      #1861    #1886    0      MN1      W=    3.60u L=1.0u
MN4273   0      #1814    #1885    0      MN1      W=    3.60u L=1.0u
MP4272   1      #1869    #1901    1      MP1      W=    3.60u L=1.0u
MP4271   1      #1813    #1900    1      MP1      W=    3.60u L=1.0u
MN4270   0      #1860    #1884    0      MN1      W=    3.60u L=1.0u
MN4269   0      #1812    #1883    0      MN1      W=    3.60u L=1.0u
MP4268   1      #1868    #1899    1      MP1      W=    3.60u L=1.0u
MP4267   1      #1811    #1898    1      MP1      W=    3.60u L=1.0u
MN4266   0      #1859    #1882    0      MN1      W=    3.60u L=1.0u
MN4265   0      #1810    #1881    0      MN1      W=    3.60u L=1.0u
MP4264   1      #1867    #1897    1      MP1      W=    3.60u L=1.0u
MP4263   1      #1809    #1896    1      MP1      W=    3.60u L=1.0u
MN4262   0      #1858    #1880    0      MN1      W=    3.60u L=1.0u
MN4261   0      #1808    #1879    0      MN1      W=    3.60u L=1.0u
MP4260   1      #1866    #1895    1      MP1      W=    3.60u L=1.0u
MP4259   1      #1807    #1894    1      MP1      W=    3.60u L=1.0u
MN4258   0      #1857    #1878    0      MN1      W=    3.60u L=1.0u
MN4257   0      #1806    #1877    0      MN1      W=    3.60u L=1.0u
MP4256   1      #1865    #1893    1      MP1      W=    3.60u L=1.0u
MP4255   1      #1805    #1892    1      MP1      W=    3.60u L=1.0u
MN4254   0      #1856    #1876    0      MN1      W=    3.60u L=1.0u
MN4253   0      #1804    #1875    0      MN1      W=    3.60u L=1.0u
MP4252   1      #1864    #1891    1      MP1      W=    3.60u L=1.0u
MP4251   1      #1803    #1890    1      MP1      W=    3.60u L=1.0u
MN4250   0      #1855    #1874    0      MN1      W=    3.60u L=1.0u
MN4249   0      #1802    #1873    0      MN1      W=    3.60u L=1.0u
MP4248   1      #1863    #1889    1      MP1      W=    3.60u L=1.0u
MP4247   1      #1801    #1888    1      MP1      W=    3.60u L=1.0u
MN4246   0      #1854    #1872    0      MN1      W=    3.60u L=1.0u
MN4245   0      #1815    #1871    0      MN1      W=    3.60u L=1.0u
MN4244   #1800    #1833    0      0      MN1      W=   14.40u L=1.0u
MP4243   #1800    #1833    1      1      MP1      W=   43.20u L=1.0u
MP4242   #1852    #1850    1      1      MP1      W=   10.80u L=1.0u
MN4241   #1574    #1849    0      0      MN1      W=   10.80u L=1.0u
MN4240   #1573    #1848    0      0      MN1      W=   10.80u L=1.0u
MN4239   #1572    #1847    0      0      MN1      W=   10.80u L=1.0u
MN4238   #1571    #1846    0      0      MN1      W=   10.80u L=1.0u
MN4237   #1570    #1845    0      0      MN1      W=   10.80u L=1.0u
MN4236   #1569    #1844    0      0      MN1      W=   10.80u L=1.0u
MN4235   #1568    #1843    0      0      MN1      W=   10.80u L=1.0u
MN4234   #1567    #1842    0      0      MN1      W=   10.80u L=1.0u
MN4233   #1566    #1841    0      0      MN1      W=   10.80u L=1.0u
MN4232   #1565    #1840    0      0      MN1      W=   10.80u L=1.0u
MN4231   #1564    #1839    0      0      MN1      W=   10.80u L=1.0u
MN4230   #1563    #1838    0      0      MN1      W=   10.80u L=1.0u
MN4229   #1562    #1837    0      0      MN1      W=   10.80u L=1.0u
MN4228   #1561    #1836    0      0      MN1      W=   10.80u L=1.0u
MN4227   #1560    #1835    0      0      MN1      W=   10.80u L=1.0u
MN4226   #1851    #1834    0      0      MN1      W=   10.80u L=1.0u
MN4225   #1852    #1850    0      0      MN1      W=   10.80u L=1.0u
MP4224   #1574    #1849    1      1      MP1      W=   10.80u L=1.0u
MP4223   #1573    #1848    1      1      MP1      W=   10.80u L=1.0u
MP4222   #1572    #1847    1      1      MP1      W=   10.80u L=1.0u
MP4221   #1571    #1846    1      1      MP1      W=   10.80u L=1.0u
MP4220   #1570    #1845    1      1      MP1      W=   10.80u L=1.0u
MP4219   #1569    #1844    1      1      MP1      W=   10.80u L=1.0u
MP4218   #1568    #1843    1      1      MP1      W=   10.80u L=1.0u
MP4217   #1567    #1842    1      1      MP1      W=   10.80u L=1.0u
MP4216   #1566    #1841    1      1      MP1      W=   10.80u L=1.0u
MP4215   #1565    #1840    1      1      MP1      W=   10.80u L=1.0u
MP4214   #1564    #1839    1      1      MP1      W=   10.80u L=1.0u
MP4213   #1563    #1838    1      1      MP1      W=   10.80u L=1.0u
MP4212   #1562    #1837    1      1      MP1      W=   10.80u L=1.0u
MP4211   #1561    #1836    1      1      MP1      W=   10.80u L=1.0u
MP4210   #1560    #1835    1      1      MP1      W=   10.80u L=1.0u
MP4209   #1851    #1834    1      1      MP1      W=   10.80u L=1.0u
MP4170   #1782    #1800    1      1      MP1      W=    3.60u L=1.0u
MP4169   #1781    #1800    1      1      MP1      W=    3.60u L=1.0u
MP4168   #1780    #1800    1      1      MP1      W=    3.60u L=1.0u
MP4167   #1779    #1800    1      1      MP1      W=    3.60u L=1.0u
MP4166   #1778    #1800    1      1      MP1      W=    3.60u L=1.0u
MP4165   #1777    #1800    1      1      MP1      W=    3.60u L=1.0u
MP4164   #1776    #1800    1      1      MP1      W=    3.60u L=1.0u
MP4163   #1775    #1800    1      1      MP1      W=    3.60u L=1.0u
MP4162   #1774    #1800    1      1      MP1      W=    3.60u L=1.0u
MP4161   #1773    #1800    1      1      MP1      W=    3.60u L=1.0u
MP4160   #1772    #1800    1      1      MP1      W=    3.60u L=1.0u
MP4159   #1771    #1800    1      1      MP1      W=    3.60u L=1.0u
MP4158   #1770    #1800    1      1      MP1      W=    3.60u L=1.0u
MP4157   #1769    #1800    1      1      MP1      W=    3.60u L=1.0u
MP4156   #1815    #1765    1      1      MP1      W=    3.60u L=1.0u
MN4155   #1832    #1765    0      0      MN1      W=    3.60u L=1.0u
MN4154   #1831    #1765    0      0      MN1      W=    3.60u L=1.0u
MN4153   #1830    #1765    0      0      MN1      W=    3.60u L=1.0u
MN4152   #1829    #1765    0      0      MN1      W=    3.60u L=1.0u
MN4151   #1828    #1765    0      0      MN1      W=    3.60u L=1.0u
MN4150   #1827    #1765    0      0      MN1      W=    3.60u L=1.0u
MN4149   #1826    #1765    0      0      MN1      W=    3.60u L=1.0u
MN4148   #1825    #1765    0      0      MN1      W=    3.60u L=1.0u
MN4147   #1824    #1765    0      0      MN1      W=    3.60u L=1.0u
MN4146   #1823    #1765    0      0      MN1      W=    3.60u L=1.0u
MN4145   #1822    #1765    0      0      MN1      W=    3.60u L=1.0u
MN4144   #1821    #1765    0      0      MN1      W=    3.60u L=1.0u
MN4143   #1820    #1765    0      0      MN1      W=    3.60u L=1.0u
MN4142   #1819    #1765    0      0      MN1      W=    3.60u L=1.0u
MN4141   #1818    #1765    0      0      MN1      W=    3.60u L=1.0u
MN4140   #1817    #1765    0      0      MN1      W=    3.60u L=1.0u
MP4139   #1768    #1800    1      1      MP1      W=    3.60u L=1.0u
MP4137   #1766    #1800    1      1      MP1      W=    3.60u L=1.0u
MN4135   #1816    #1765    0      0      MN1      W=    3.60u L=1.0u
MP4134   #1814    #51      #1782    1      MP1      W=    3.60u L=1.0u
MP4133   #1813    #50      #1781    1      MP1      W=    3.60u L=1.0u
MP4132   #1812    #49      #1780    1      MP1      W=    3.60u L=1.0u
MP4131   #1811    #48      #1779    1      MP1      W=    3.60u L=1.0u
MP4130   #1810    #47      #1778    1      MP1      W=    3.60u L=1.0u
MP4129   #1809    #46      #1777    1      MP1      W=    3.60u L=1.0u
MP4128   #1808    #45      #1776    1      MP1      W=    3.60u L=1.0u
MP4127   #1807    #44      #1775    1      MP1      W=    3.60u L=1.0u
MP4126   #1806    #43      #1774    1      MP1      W=    3.60u L=1.0u
MP4125   #1805    #42      #1773    1      MP1      W=    3.60u L=1.0u
MP4124   #1804    #41      #1772    1      MP1      W=    3.60u L=1.0u
MP4123   #1803    #40      #1771    1      MP1      W=    3.60u L=1.0u
MP4122   #1802    #39      #1770    1      MP1      W=    3.60u L=1.0u
MP4121   #1801    #38      #1769    1      MP1      W=    3.60u L=1.0u
MN4120   #1799    #52      #1832    0      MN1      W=    3.60u L=1.0u
MN4119   #1814    #51      #1831    0      MN1      W=    3.60u L=1.0u
MN4118   #1813    #50      #1830    0      MN1      W=    3.60u L=1.0u
MN4117   #1812    #49      #1829    0      MN1      W=    3.60u L=1.0u
MN4116   #1811    #48      #1828    0      MN1      W=    3.60u L=1.0u
MN4115   #1810    #47      #1827    0      MN1      W=    3.60u L=1.0u
MN4114   #1809    #46      #1826    0      MN1      W=    3.60u L=1.0u
MN4113   #1808    #45      #1825    0      MN1      W=    3.60u L=1.0u
MN4112   #1807    #44      #1824    0      MN1      W=    3.60u L=1.0u
MN4111   #1806    #43      #1823    0      MN1      W=    3.60u L=1.0u
MN4110   #1805    #42      #1822    0      MN1      W=    3.60u L=1.0u
MN4109   #1804    #41      #1821    0      MN1      W=    3.60u L=1.0u
MN4108   #1803    #40      #1820    0      MN1      W=    3.60u L=1.0u
MN4107   #1802    #39      #1819    0      MN1      W=    3.60u L=1.0u
MN4106   #1801    #38      #1818    0      MN1      W=    3.60u L=1.0u
MN4105   #1815    #37      #1817    0      MN1      W=    3.60u L=1.0u
MP4104   1      #37      #1815    1      MP1      W=    3.60u L=1.0u
MP4103   #1799    #52      #1768    1      MP1      W=    3.60u L=1.0u
MP4102   #1798    #52      #1766    1      MP1      W=    3.60u L=1.0u
MN4101   #1765    #1764    0      0      MN1      W=   14.40u L=1.0u
MN4100   #1798    #52      #1816    0      MN1      W=    3.60u L=1.0u
MP4099   #1765    #1764    1      1      MP1      W=   43.20u L=1.0u
MN4098   #1797    #1800    #1799    0      MN1      W=    3.60u L=1.0u
MN4097   #1796    #1800    #1814    0      MN1      W=    3.60u L=1.0u
MN4096   #1795    #1800    #1813    0      MN1      W=    3.60u L=1.0u
MN4095   #1794    #1800    #1812    0      MN1      W=    3.60u L=1.0u
MN4094   #1793    #1800    #1811    0      MN1      W=    3.60u L=1.0u
MN4093   #1792    #1800    #1810    0      MN1      W=    3.60u L=1.0u
MN4092   #1791    #1800    #1809    0      MN1      W=    3.60u L=1.0u
MN4091   #1790    #1800    #1808    0      MN1      W=    3.60u L=1.0u
MN4090   #1789    #1800    #1807    0      MN1      W=    3.60u L=1.0u
MN4089   #1788    #1800    #1806    0      MN1      W=    3.60u L=1.0u
MN4088   #1787    #1800    #1805    0      MN1      W=    3.60u L=1.0u
MN4087   #1786    #1800    #1804    0      MN1      W=    3.60u L=1.0u
MN4086   #1785    #1800    #1803    0      MN1      W=    3.60u L=1.0u
MN4085   #1784    #1800    #1802    0      MN1      W=    3.60u L=1.0u
MP4084   #1782    #1765    #1814    1      MP1      W=    3.60u L=1.0u
MP4083   #1781    #1765    #1813    1      MP1      W=    3.60u L=1.0u
MP4082   #1780    #1765    #1812    1      MP1      W=    3.60u L=1.0u
MP4081   #1779    #1765    #1811    1      MP1      W=    3.60u L=1.0u
MP4080   #1778    #1765    #1810    1      MP1      W=    3.60u L=1.0u
MP4079   #1777    #1765    #1809    1      MP1      W=    3.60u L=1.0u
MP4078   #1776    #1765    #1808    1      MP1      W=    3.60u L=1.0u
MP4077   #1775    #1765    #1807    1      MP1      W=    3.60u L=1.0u
MP4076   #1774    #1765    #1806    1      MP1      W=    3.60u L=1.0u
MP4075   #1773    #1765    #1805    1      MP1      W=    3.60u L=1.0u
MP4074   #1772    #1765    #1804    1      MP1      W=    3.60u L=1.0u
MP4073   #1771    #1765    #1803    1      MP1      W=    3.60u L=1.0u
MP4072   #1770    #1765    #1802    1      MP1      W=    3.60u L=1.0u
MP4071   #1769    #1765    #1801    1      MP1      W=    3.60u L=1.0u
MN4070   #1783    #1800    #1801    0      MN1      W=    3.60u L=1.0u
MN4069   #1767    #1800    #1798    0      MN1      W=    3.60u L=1.0u
MP4067   #1768    #1765    #1799    1      MP1      W=    3.60u L=1.0u
MP4065   #1766    #1765    #1798    1      MP1      W=    3.60u L=1.0u
MN4064   0      #51      #1797    0      MN1      W=    3.60u L=1.0u
MN4063   0      #50      #1796    0      MN1      W=    3.60u L=1.0u
MN4062   0      #49      #1795    0      MN1      W=    3.60u L=1.0u
MN4061   0      #48      #1794    0      MN1      W=    3.60u L=1.0u
MN4060   0      #47      #1793    0      MN1      W=    3.60u L=1.0u
MN4059   0      #46      #1792    0      MN1      W=    3.60u L=1.0u
MN4058   0      #45      #1791    0      MN1      W=    3.60u L=1.0u
MN4057   0      #44      #1790    0      MN1      W=    3.60u L=1.0u
MN4056   0      #43      #1789    0      MN1      W=    3.60u L=1.0u
MN4055   0      #42      #1788    0      MN1      W=    3.60u L=1.0u
MN4054   0      #41      #1787    0      MN1      W=    3.60u L=1.0u
MN4053   0      #40      #1786    0      MN1      W=    3.60u L=1.0u
MN4052   0      #39      #1785    0      MN1      W=    3.60u L=1.0u
MN4051   0      #38      #1784    0      MN1      W=    3.60u L=1.0u
MN4050   0      #37      #1783    0      MN1      W=    3.60u L=1.0u
MP4049   1      #50      #1782    1      MP1      W=    3.60u L=1.0u
MP4048   1      #49      #1781    1      MP1      W=    3.60u L=1.0u
MP4047   1      #48      #1780    1      MP1      W=    3.60u L=1.0u
MP4046   1      #47      #1779    1      MP1      W=    3.60u L=1.0u
MP4045   1      #46      #1778    1      MP1      W=    3.60u L=1.0u
MP4044   1      #45      #1777    1      MP1      W=    3.60u L=1.0u
MP4043   1      #44      #1776    1      MP1      W=    3.60u L=1.0u
MP4042   1      #43      #1775    1      MP1      W=    3.60u L=1.0u
MP4041   1      #42      #1774    1      MP1      W=    3.60u L=1.0u
MP4040   1      #41      #1773    1      MP1      W=    3.60u L=1.0u
MP4039   1      #40      #1772    1      MP1      W=    3.60u L=1.0u
MP4038   1      #39      #1771    1      MP1      W=    3.60u L=1.0u
MP4037   1      #38      #1770    1      MP1      W=    3.60u L=1.0u
MP4036   1      #37      #1769    1      MP1      W=    3.60u L=1.0u
MN4035   0      #52      #1767    0      MN1      W=    3.60u L=1.0u
MP4034   1      #51      #1768    1      MP1      W=    3.60u L=1.0u
MP4033   1      #52      #1766    1      MP1      W=    3.60u L=1.0u
MN4030   #1749    #1666    0      0      MN1      W=   10.80u L=1.0u
MP4029   #1749    #1666    1      1      MP1      W=   10.80u L=1.0u
MN4028   #1756    #1673    0      0      MN1      W=   10.80u L=1.0u
MN4027   #1763    #1680    0      0      MN1      W=   10.80u L=1.0u
MN4026   #1755    #1672    0      0      MN1      W=   10.80u L=1.0u
MN4025   #1762    #1679    0      0      MN1      W=   10.80u L=1.0u
MN4024   #1754    #1671    0      0      MN1      W=   10.80u L=1.0u
MN4023   #1761    #1678    0      0      MN1      W=   10.80u L=1.0u
MN4022   #1753    #1670    0      0      MN1      W=   10.80u L=1.0u
MN4021   #1760    #1677    0      0      MN1      W=   10.80u L=1.0u
MN4020   #1752    #1669    0      0      MN1      W=   10.80u L=1.0u
MN4019   #1759    #1676    0      0      MN1      W=   10.80u L=1.0u
MN4018   #1751    #1668    0      0      MN1      W=   10.80u L=1.0u
MN4017   #1758    #1675    0      0      MN1      W=   10.80u L=1.0u
MN4016   #1750    #1667    0      0      MN1      W=   10.80u L=1.0u
MN4015   #1757    #1674    0      0      MN1      W=   10.80u L=1.0u
MP4014   #1756    #1673    1      1      MP1      W=   10.80u L=1.0u
MP4013   #1763    #1680    1      1      MP1      W=   10.80u L=1.0u
MP4012   #1755    #1672    1      1      MP1      W=   10.80u L=1.0u
MP4011   #1762    #1679    1      1      MP1      W=   10.80u L=1.0u
MP4010   #1754    #1671    1      1      MP1      W=   10.80u L=1.0u
MP4009   #1761    #1678    1      1      MP1      W=   10.80u L=1.0u
MP4008   #1753    #1670    1      1      MP1      W=   10.80u L=1.0u
MP4007   #1760    #1677    1      1      MP1      W=   10.80u L=1.0u
MP4006   #1752    #1669    1      1      MP1      W=   10.80u L=1.0u
MP4005   #1759    #1676    1      1      MP1      W=   10.80u L=1.0u
MP4004   #1751    #1668    1      1      MP1      W=   10.80u L=1.0u
MP4003   #1758    #1675    1      1      MP1      W=   10.80u L=1.0u
MP4002   #1750    #1667    1      1      MP1      W=   10.80u L=1.0u
MP4001   #1757    #1674    1      1      MP1      W=   10.80u L=1.0u
MN3975   0      #1629    #1729    0      MN1      W=    1.80u L=1.0u
MN3967   Z23      #1681    0      0      MN1      W=    3.60u L=1.0u
MP3966   Z23      #1681    1      1      MP1      W=    3.60u L=1.0u
MP3965   #1748    #1595    1      1      MP1      W=    1.80u L=1.0u
MN3964   #1714    #1560    0      0      MN1      W=    5.40u L=1.0u
MP3963   #1744    #1560    1      1      MP1      W=    5.40u L=1.0u
MN3962   #1729    #1595    0      0      MN1      W=    1.80u L=1.0u
MP3961   #1746    #1333    1      1      MP1      W=    5.40u L=1.0u
MN3960   #1728    #1574    0      0      MN1      W=    5.40u L=1.0u
MN3959   #1726    #1572    0      0      MN1      W=    5.40u L=1.0u
MN3958   #1724    #1570    0      0      MN1      W=    5.40u L=1.0u
MN3957   #1722    #1568    0      0      MN1      W=    5.40u L=1.0u
MN3956   #1720    #1566    0      0      MN1      W=    5.40u L=1.0u
MN3955   #1718    #1564    0      0      MN1      W=    5.40u L=1.0u
MN3954   #1716    #1562    0      0      MN1      W=    5.40u L=1.0u
MP3953   #1743    #1574    1      1      MP1      W=    5.40u L=1.0u
MP3952   #1741    #1572    1      1      MP1      W=    5.40u L=1.0u
MP3951   #1739    #1570    1      1      MP1      W=    5.40u L=1.0u
MP3950   #1737    #1568    1      1      MP1      W=    5.40u L=1.0u
MP3949   #1735    #1566    1      1      MP1      W=    5.40u L=1.0u
MP3948   #1733    #1564    1      1      MP1      W=    5.40u L=1.0u
MP3947   #1731    #1562    1      1      MP1      W=    5.40u L=1.0u
MN3946   #1745    #1333    0      0      MN1      W=    5.40u L=1.0u
MP3945   #1742    #1573    1      1      MP1      W=    5.40u L=1.0u
MP3944   #1740    #1571    1      1      MP1      W=    5.40u L=1.0u
MP3943   #1738    #1569    1      1      MP1      W=    5.40u L=1.0u
MP3942   #1736    #1567    1      1      MP1      W=    5.40u L=1.0u
MP3941   #1734    #1565    1      1      MP1      W=    5.40u L=1.0u
MP3940   #1732    #1563    1      1      MP1      W=    5.40u L=1.0u
MP3939   #1730    #1561    1      1      MP1      W=    5.40u L=1.0u
MN3938   #1727    #1573    0      0      MN1      W=    5.40u L=1.0u
MN3937   #1725    #1571    0      0      MN1      W=    5.40u L=1.0u
MN3936   #1723    #1569    0      0      MN1      W=    5.40u L=1.0u
MN3935   #1721    #1567    0      0      MN1      W=    5.40u L=1.0u
MN3934   #1719    #1565    0      0      MN1      W=    5.40u L=1.0u
MN3933   #1717    #1563    0      0      MN1      W=    5.40u L=1.0u
MN3932   #1715    #1561    0      0      MN1      W=    5.40u L=1.0u
MP3931   #1681    #1629    #1748    1      MP1      W=    1.80u L=1.0u
MP3930   #1713    #1575    #1746    1      MP1      W=    5.40u L=1.0u
MN3929   #1712    #1575    #1745    0      MN1      W=    5.40u L=1.0u
MP3928   #1711    #1430    #1744    1      MP1      W=    5.40u L=1.0u
MP3927   #1710    #1332    #1743    1      MP1      W=    5.40u L=1.0u
MP3926   #1709    #1339    #1742    1      MP1      W=    5.40u L=1.0u
MP3925   #1708    #1331    #1741    1      MP1      W=    5.40u L=1.0u
MP3924   #1707    #1338    #1740    1      MP1      W=    5.40u L=1.0u
MP3923   #1706    #1330    #1739    1      MP1      W=    5.40u L=1.0u
MP3922   #1705    #1337    #1738    1      MP1      W=    5.40u L=1.0u
MP3921   #1704    #1329    #1737    1      MP1      W=    5.40u L=1.0u
MP3920   #1703    #1336    #1736    1      MP1      W=    5.40u L=1.0u
MP3919   #1702    #1328    #1735    1      MP1      W=    5.40u L=1.0u
MP3918   #1701    #1335    #1734    1      MP1      W=    5.40u L=1.0u
MP3917   #1700    #1327    #1733    1      MP1      W=    5.40u L=1.0u
MP3916   #1699    #1334    #1732    1      MP1      W=    5.40u L=1.0u
MP3915   #1698    #1326    #1731    1      MP1      W=    5.40u L=1.0u
MP3914   #1697    #1428    #1730    1      MP1      W=    5.40u L=1.0u
MN3913   #1681    #1665    #1729    0      MN1      W=    1.80u L=1.0u
MN3912   #1696    #1332    #1728    0      MN1      W=    5.40u L=1.0u
MN3911   #1695    #1339    #1727    0      MN1      W=    5.40u L=1.0u
MN3910   #1694    #1331    #1726    0      MN1      W=    5.40u L=1.0u
MN3909   #1693    #1338    #1725    0      MN1      W=    5.40u L=1.0u
MN3908   #1692    #1330    #1724    0      MN1      W=    5.40u L=1.0u
MN3907   #1691    #1337    #1723    0      MN1      W=    5.40u L=1.0u
MN3906   #1690    #1329    #1722    0      MN1      W=    5.40u L=1.0u
MN3905   #1689    #1336    #1721    0      MN1      W=    5.40u L=1.0u
MN3904   #1688    #1328    #1720    0      MN1      W=    5.40u L=1.0u
MN3903   #1687    #1335    #1719    0      MN1      W=    5.40u L=1.0u
MN3902   #1686    #1327    #1718    0      MN1      W=    5.40u L=1.0u
MN3901   #1685    #1334    #1717    0      MN1      W=    5.40u L=1.0u
MN3900   #1684    #1326    #1716    0      MN1      W=    5.40u L=1.0u
MN3899   #1683    #1428    #1715    0      MN1      W=    5.40u L=1.0u
MN3898   #1682    #1430    #1714    0      MN1      W=    5.40u L=1.0u
MP3897   Z24      #1665    #1713    1      MP1      W=    5.40u L=1.0u
MN3896   Z24      #1665    #1712    0      MN1      W=    5.40u L=1.0u
MP3895   #1666    #1429    #1711    1      MP1      W=    1.80u L=1.0u
MN3894   #1673    #1593    #1696    0      MN1      W=    1.80u L=1.0u
MP3893   #1673    #1593    #1710    1      MP1      W=    1.80u L=1.0u
MP3892   #1680    #1592    #1709    1      MP1      W=    1.80u L=1.0u
MN3891   #1680    #1592    #1695    0      MN1      W=    1.80u L=1.0u
MN3890   #1672    #1591    #1694    0      MN1      W=    1.80u L=1.0u
MP3889   #1672    #1591    #1708    1      MP1      W=    1.80u L=1.0u
MP3888   #1679    #1590    #1707    1      MP1      W=    1.80u L=1.0u
MN3887   #1679    #1590    #1693    0      MN1      W=    1.80u L=1.0u
MN3886   #1671    #1589    #1692    0      MN1      W=    1.80u L=1.0u
MP3885   #1671    #1589    #1706    1      MP1      W=    1.80u L=1.0u
MP3884   #1678    #1588    #1705    1      MP1      W=    1.80u L=1.0u
MN3883   #1678    #1588    #1691    0      MN1      W=    1.80u L=1.0u
MN3882   #1670    #1587    #1690    0      MN1      W=    1.80u L=1.0u
MP3881   #1670    #1587    #1704    1      MP1      W=    1.80u L=1.0u
MP3880   #1677    #1586    #1703    1      MP1      W=    1.80u L=1.0u
MN3879   #1677    #1586    #1689    0      MN1      W=    1.80u L=1.0u
MN3878   #1669    #1585    #1688    0      MN1      W=    1.80u L=1.0u
MP3877   #1669    #1585    #1702    1      MP1      W=    1.80u L=1.0u
MP3876   #1676    #1584    #1701    1      MP1      W=    1.80u L=1.0u
MN3875   #1676    #1584    #1687    0      MN1      W=    1.80u L=1.0u
MN3874   #1668    #1583    #1686    0      MN1      W=    1.80u L=1.0u
MP3873   #1668    #1583    #1700    1      MP1      W=    1.80u L=1.0u
MP3872   #1675    #1582    #1699    1      MP1      W=    1.80u L=1.0u
MN3871   #1675    #1582    #1685    0      MN1      W=    1.80u L=1.0u
MN3870   #1667    #1581    #1684    0      MN1      W=    1.80u L=1.0u
MP3869   #1667    #1581    #1698    1      MP1      W=    1.80u L=1.0u
MP3868   #1674    #1580    #1697    1      MP1      W=    1.80u L=1.0u
MN3867   #1674    #1580    #1683    0      MN1      W=    1.80u L=1.0u
MP3866   1      #1665    #1681    1      MP1      W=    1.80u L=1.0u
MN3865   #1666    #1429    #1682    0      MN1      W=    1.80u L=1.0u
MP3864   #1661    #1170    Z24      1      MP1      W=    1.80u L=1.0u
MN3863   #1660    #1170    Z24      0      MN1      W=    1.80u L=1.0u
MN3862   #1643    #1593    #1680    0      MN1      W=    1.80u L=1.0u
MN3861   #1641    #1591    #1679    0      MN1      W=    1.80u L=1.0u
MN3860   #1639    #1589    #1678    0      MN1      W=    1.80u L=1.0u
MN3859   #1637    #1587    #1677    0      MN1      W=    1.80u L=1.0u
MN3858   #1635    #1585    #1676    0      MN1      W=    1.80u L=1.0u
MN3857   #1633    #1583    #1675    0      MN1      W=    1.80u L=1.0u
MN3856   #1631    #1581    #1674    0      MN1      W=    1.80u L=1.0u
MP3855   #1659    #1580    #1666    1      MP1      W=    1.80u L=1.0u
MP3854   #1658    #1517    #1673    1      MP1      W=    1.80u L=1.0u
MP3853   #1657    #1593    #1680    1      MP1      W=    1.80u L=1.0u
MP3852   #1656    #1592    #1672    1      MP1      W=    1.80u L=1.0u
MP3851   #1655    #1591    #1679    1      MP1      W=    1.80u L=1.0u
MP3850   #1654    #1590    #1671    1      MP1      W=    1.80u L=1.0u
MP3849   #1653    #1589    #1678    1      MP1      W=    1.80u L=1.0u
MP3848   #1652    #1588    #1670    1      MP1      W=    1.80u L=1.0u
MP3847   #1651    #1587    #1677    1      MP1      W=    1.80u L=1.0u
MP3846   #1650    #1586    #1669    1      MP1      W=    1.80u L=1.0u
MP3845   #1649    #1585    #1676    1      MP1      W=    1.80u L=1.0u
MP3844   #1648    #1584    #1668    1      MP1      W=    1.80u L=1.0u
MP3843   #1647    #1583    #1675    1      MP1      W=    1.80u L=1.0u
MP3842   #1646    #1582    #1667    1      MP1      W=    1.80u L=1.0u
MP3841   #1645    #1581    #1674    1      MP1      W=    1.80u L=1.0u
MN3840   #1644    #1517    #1673    0      MN1      W=    1.80u L=1.0u
MN3839   #1642    #1592    #1672    0      MN1      W=    1.80u L=1.0u
MN3838   #1640    #1590    #1671    0      MN1      W=    1.80u L=1.0u
MN3837   #1638    #1588    #1670    0      MN1      W=    1.80u L=1.0u
MN3836   #1636    #1586    #1669    0      MN1      W=    1.80u L=1.0u
MN3835   #1634    #1584    #1668    0      MN1      W=    1.80u L=1.0u
MN3834   #1632    #1582    #1667    0      MN1      W=    1.80u L=1.0u
MN3833   #1630    #1580    #1666    0      MN1      W=    1.80u L=1.0u
MP3832   #1665    #1629    1      1      MP1      W=    1.80u L=1.0u
MP3831   #1662    X7       1      1      MP1      W=   10.80u L=1.0u
MN3830   #1663    X7       #1662    0      MN1      W=    3.60u L=1.0u
MN3829   #1664    #1629    #1665    0      MN1      W=    1.80u L=1.0u
MP3828   1      #1665    #1661    1      MP1      W=    5.40u L=1.0u
MN3827   0      #1665    #1660    0      MN1      W=    5.40u L=1.0u
MN3826   0      #1592    #1643    0      MN1      W=    1.80u L=1.0u
MN3825   0      #1590    #1641    0      MN1      W=    1.80u L=1.0u
MN3824   0      #1588    #1639    0      MN1      W=    1.80u L=1.0u
MN3823   0      #1586    #1637    0      MN1      W=    1.80u L=1.0u
MN3822   0      #1584    #1635    0      MN1      W=    1.80u L=1.0u
MN3821   0      #1582    #1633    0      MN1      W=    1.80u L=1.0u
MN3820   0      #1580    #1631    0      MN1      W=    1.80u L=1.0u
MP3819   1      #1429    #1659    1      MP1      W=    1.80u L=1.0u
MN3818   0      #1593    #1644    0      MN1      W=    1.80u L=1.0u
MP3817   1      #1593    #1658    1      MP1      W=    1.80u L=1.0u
MP3816   1      #1592    #1657    1      MP1      W=    1.80u L=1.0u
MN3815   0      #1591    #1642    0      MN1      W=    1.80u L=1.0u
MP3814   1      #1591    #1656    1      MP1      W=    1.80u L=1.0u
MP3813   1      #1590    #1655    1      MP1      W=    1.80u L=1.0u
MN3812   0      #1589    #1640    0      MN1      W=    1.80u L=1.0u
MP3811   1      #1589    #1654    1      MP1      W=    1.80u L=1.0u
MP3810   1      #1588    #1653    1      MP1      W=    1.80u L=1.0u
MN3809   0      #1587    #1638    0      MN1      W=    1.80u L=1.0u
MP3808   1      #1587    #1652    1      MP1      W=    1.80u L=1.0u
MP3807   1      #1586    #1651    1      MP1      W=    1.80u L=1.0u
MN3806   0      #1585    #1636    0      MN1      W=    1.80u L=1.0u
MP3805   1      #1585    #1650    1      MP1      W=    1.80u L=1.0u
MP3804   1      #1584    #1649    1      MP1      W=    1.80u L=1.0u
MN3803   0      #1583    #1634    0      MN1      W=    1.80u L=1.0u
MP3802   1      #1583    #1648    1      MP1      W=    1.80u L=1.0u
MP3801   1      #1582    #1647    1      MP1      W=    1.80u L=1.0u
MN3800   0      #1581    #1632    0      MN1      W=    1.80u L=1.0u
MP3799   1      #1581    #1646    1      MP1      W=    1.80u L=1.0u
MP3798   1      #1580    #1645    1      MP1      W=    1.80u L=1.0u
MN3797   0      #1429    #1630    0      MN1      W=    1.80u L=1.0u
MP3796   1      #1595    #1665    1      MP1      W=    1.80u L=1.0u
MP3795   1      X8       #1662    1      MP1      W=   10.80u L=1.0u
MN3794   0      #1595    #1664    0      MN1      W=    1.80u L=1.0u
MN3793   0      X8       #1663    0      MN1      W=    3.60u L=1.0u
MP3792   #1661    #1333    1      1      MP1      W=    5.40u L=1.0u
MN3791   #1660    #1333    0      0      MN1      W=    5.40u L=1.0u
MP3790   #1659    #1430    1      1      MP1      W=    5.40u L=1.0u
MP3789   #1658    #1332    1      1      MP1      W=    5.40u L=1.0u
MP3788   #1657    #1339    1      1      MP1      W=    5.40u L=1.0u
MP3787   #1656    #1331    1      1      MP1      W=    5.40u L=1.0u
MP3786   #1655    #1338    1      1      MP1      W=    5.40u L=1.0u
MP3785   #1654    #1330    1      1      MP1      W=    5.40u L=1.0u
MP3784   #1653    #1337    1      1      MP1      W=    5.40u L=1.0u
MP3783   #1652    #1329    1      1      MP1      W=    5.40u L=1.0u
MP3782   #1651    #1336    1      1      MP1      W=    5.40u L=1.0u
MP3781   #1650    #1328    1      1      MP1      W=    5.40u L=1.0u
MP3780   #1649    #1335    1      1      MP1      W=    5.40u L=1.0u
MP3779   #1648    #1327    1      1      MP1      W=    5.40u L=1.0u
MP3778   #1647    #1334    1      1      MP1      W=    5.40u L=1.0u
MP3777   #1646    #1326    1      1      MP1      W=    5.40u L=1.0u
MP3776   #1645    #1428    1      1      MP1      W=    5.40u L=1.0u
MN3775   #1644    #1332    0      0      MN1      W=    5.40u L=1.0u
MN3774   #1643    #1339    0      0      MN1      W=    5.40u L=1.0u
MN3773   #1642    #1331    0      0      MN1      W=    5.40u L=1.0u
MN3772   #1641    #1338    0      0      MN1      W=    5.40u L=1.0u
MN3771   #1640    #1330    0      0      MN1      W=    5.40u L=1.0u
MN3770   #1639    #1337    0      0      MN1      W=    5.40u L=1.0u
MN3769   #1638    #1329    0      0      MN1      W=    5.40u L=1.0u
MN3768   #1637    #1336    0      0      MN1      W=    5.40u L=1.0u
MN3767   #1636    #1328    0      0      MN1      W=    5.40u L=1.0u
MN3766   #1635    #1335    0      0      MN1      W=    5.40u L=1.0u
MN3765   #1634    #1327    0      0      MN1      W=    5.40u L=1.0u
MN3764   #1633    #1334    0      0      MN1      W=    5.40u L=1.0u
MN3763   #1632    #1326    0      0      MN1      W=    5.40u L=1.0u
MN3762   #1631    #1428    0      0      MN1      W=    5.40u L=1.0u
MN3761   #1630    #1430    0      0      MN1      W=    5.40u L=1.0u
MN3760   #1629    #1558    0      0      MN1      W=    1.80u L=1.0u
MP3759   #1629    #1558    1      1      MP1      W=    1.80u L=1.0u
MN3758   #1596    #1662    0      0      MN1      W=    3.60u L=1.0u
MP3757   #1342    #1662    1      1      MP1      W=   10.80u L=1.0u
MP3756   1      #1575    #1661    1      MP1      W=    5.40u L=1.0u
MN3755   0      #1575    #1660    0      MN1      W=    5.40u L=1.0u
MP3754   1      #1560    #1659    1      MP1      W=    5.40u L=1.0u
MN3753   0      #1574    #1644    0      MN1      W=    5.40u L=1.0u
MP3752   1      #1574    #1658    1      MP1      W=    5.40u L=1.0u
MP3751   1      #1573    #1657    1      MP1      W=    5.40u L=1.0u
MN3750   0      #1573    #1643    0      MN1      W=    5.40u L=1.0u
MN3749   0      #1572    #1642    0      MN1      W=    5.40u L=1.0u
MP3748   1      #1572    #1656    1      MP1      W=    5.40u L=1.0u
MP3747   1      #1571    #1655    1      MP1      W=    5.40u L=1.0u
MN3746   0      #1571    #1641    0      MN1      W=    5.40u L=1.0u
MN3745   0      #1570    #1640    0      MN1      W=    5.40u L=1.0u
MP3744   1      #1570    #1654    1      MP1      W=    5.40u L=1.0u
MP3743   1      #1569    #1653    1      MP1      W=    5.40u L=1.0u
MN3742   0      #1569    #1639    0      MN1      W=    5.40u L=1.0u
MN3741   0      #1568    #1638    0      MN1      W=    5.40u L=1.0u
MP3740   1      #1568    #1652    1      MP1      W=    5.40u L=1.0u
MP3739   1      #1567    #1651    1      MP1      W=    5.40u L=1.0u
MN3738   0      #1567    #1637    0      MN1      W=    5.40u L=1.0u
MN3737   0      #1566    #1636    0      MN1      W=    5.40u L=1.0u
MP3736   1      #1566    #1650    1      MP1      W=    5.40u L=1.0u
MP3735   1      #1565    #1649    1      MP1      W=    5.40u L=1.0u
MN3734   0      #1565    #1635    0      MN1      W=    5.40u L=1.0u
MN3733   0      #1564    #1634    0      MN1      W=    5.40u L=1.0u
MP3732   1      #1564    #1648    1      MP1      W=    5.40u L=1.0u
MP3731   1      #1563    #1647    1      MP1      W=    5.40u L=1.0u
MN3730   0      #1563    #1633    0      MN1      W=    5.40u L=1.0u
MN3729   0      #1562    #1632    0      MN1      W=    5.40u L=1.0u
MP3728   1      #1562    #1646    1      MP1      W=    5.40u L=1.0u
MP3727   1      #1561    #1645    1      MP1      W=    5.40u L=1.0u
MN3726   0      #1561    #1631    0      MN1      W=    5.40u L=1.0u
MN3725   0      #1560    #1630    0      MN1      W=    5.40u L=1.0u
MN3724   #1342    X8       #1596    0      MN1      W=    3.60u L=1.0u
MP3723   #1628    X8       #1342    1      MP1      W=   10.80u L=1.0u
MP3722   #1553    #1520    1      1      MP1      W=   16.20u L=1.0u
MN3721   #1521    #1575    0      0      MN1      W=   10.80u L=1.0u
MP3720   #1612    #1560    1      1      MP1      W=    5.40u L=1.0u
MP3719   #1626    #1574    1      1      MP1      W=    5.40u L=1.0u
MP3718   #1625    #1573    1      1      MP1      W=    5.40u L=1.0u
MP3717   #1624    #1572    1      1      MP1      W=    5.40u L=1.0u
MP3716   #1623    #1571    1      1      MP1      W=    5.40u L=1.0u
MP3715   #1622    #1570    1      1      MP1      W=    5.40u L=1.0u
MP3714   #1621    #1569    1      1      MP1      W=    5.40u L=1.0u
MP3713   #1620    #1568    1      1      MP1      W=    5.40u L=1.0u
MP3712   #1619    #1567    1      1      MP1      W=    5.40u L=1.0u
MP3711   #1618    #1566    1      1      MP1      W=    5.40u L=1.0u
MP3710   #1617    #1565    1      1      MP1      W=    5.40u L=1.0u
MP3709   #1616    #1564    1      1      MP1      W=    5.40u L=1.0u
MP3708   #1615    #1563    1      1      MP1      W=    5.40u L=1.0u
MP3707   #1614    #1562    1      1      MP1      W=    5.40u L=1.0u
MP3706   #1613    #1561    1      1      MP1      W=    5.40u L=1.0u
MN3705   #1611    #1574    0      0      MN1      W=    5.40u L=1.0u
MN3704   #1610    #1573    0      0      MN1      W=    5.40u L=1.0u
MN3703   #1609    #1572    0      0      MN1      W=    5.40u L=1.0u
MN3702   #1608    #1571    0      0      MN1      W=    5.40u L=1.0u
MN3701   #1607    #1570    0      0      MN1      W=    5.40u L=1.0u
MN3700   #1606    #1569    0      0      MN1      W=    5.40u L=1.0u
MN3699   #1605    #1568    0      0      MN1      W=    5.40u L=1.0u
MN3698   #1604    #1567    0      0      MN1      W=    5.40u L=1.0u
MN3697   #1603    #1566    0      0      MN1      W=    5.40u L=1.0u
MN3696   #1602    #1565    0      0      MN1      W=    5.40u L=1.0u
MN3695   #1601    #1564    0      0      MN1      W=    5.40u L=1.0u
MN3694   #1600    #1563    0      0      MN1      W=    5.40u L=1.0u
MN3693   #1599    #1562    0      0      MN1      W=    5.40u L=1.0u
MN3692   #1598    #1561    0      0      MN1      W=    5.40u L=1.0u
MP3691   1      X7       #1628    1      MP1      W=   10.80u L=1.0u
MN3690   #1597    #1560    0      0      MN1      W=    5.40u L=1.0u
MN3689   #1596    X7       #1342    0      MN1      W=    3.60u L=1.0u
MP3688   #1595    #1520    1      1      MP1      W=    5.40u L=1.0u
MN3687   #1594    #1520    #1595    0      MN1      W=    5.40u L=1.0u
MP3686   #1517    #1332    #1626    1      MP1      W=    5.40u L=1.0u
MP3685   #1593    #1339    #1625    1      MP1      W=    5.40u L=1.0u
MP3684   #1592    #1331    #1624    1      MP1      W=    5.40u L=1.0u
MP3683   #1591    #1338    #1623    1      MP1      W=    5.40u L=1.0u
MP3682   #1590    #1330    #1622    1      MP1      W=    5.40u L=1.0u
MP3681   #1589    #1337    #1621    1      MP1      W=    5.40u L=1.0u
MP3680   #1588    #1329    #1620    1      MP1      W=    5.40u L=1.0u
MP3679   #1587    #1336    #1619    1      MP1      W=    5.40u L=1.0u
MP3678   #1586    #1328    #1618    1      MP1      W=    5.40u L=1.0u
MP3677   #1585    #1335    #1617    1      MP1      W=    5.40u L=1.0u
MP3676   #1584    #1327    #1616    1      MP1      W=    5.40u L=1.0u
MP3675   #1583    #1334    #1615    1      MP1      W=    5.40u L=1.0u
MP3674   #1582    #1326    #1614    1      MP1      W=    5.40u L=1.0u
MP3673   #1581    #1428    #1613    1      MP1      W=    5.40u L=1.0u
MP3672   #1580    #1430    #1612    1      MP1      W=    5.40u L=1.0u
MN3671   #1517    #1332    #1611    0      MN1      W=    5.40u L=1.0u
MN3670   #1593    #1339    #1610    0      MN1      W=    5.40u L=1.0u
MN3669   #1592    #1331    #1609    0      MN1      W=    5.40u L=1.0u
MN3668   #1591    #1338    #1608    0      MN1      W=    5.40u L=1.0u
MN3667   #1590    #1330    #1607    0      MN1      W=    5.40u L=1.0u
MN3666   #1589    #1337    #1606    0      MN1      W=    5.40u L=1.0u
MN3665   #1588    #1329    #1605    0      MN1      W=    5.40u L=1.0u
MN3664   #1587    #1336    #1604    0      MN1      W=    5.40u L=1.0u
MN3663   #1586    #1328    #1603    0      MN1      W=    5.40u L=1.0u
MN3662   #1585    #1335    #1602    0      MN1      W=    5.40u L=1.0u
MN3661   #1584    #1327    #1601    0      MN1      W=    5.40u L=1.0u
MN3660   #1583    #1334    #1600    0      MN1      W=    5.40u L=1.0u
MN3659   #1582    #1326    #1599    0      MN1      W=    5.40u L=1.0u
MN3658   #1581    #1428    #1598    0      MN1      W=    5.40u L=1.0u
MN3657   #1580    #1430    #1597    0      MN1      W=    5.40u L=1.0u
MP3656   1      #1333    #1553    1      MP1      W=   10.80u L=1.0u
MN3655   0      #1333    #1521    0      MN1      W=   16.20u L=1.0u
MP3654   #1559    X9       1      1      MP1      W=   10.80u L=1.0u
MP3653   1      #1578    #1595    1      MP1      W=    5.40u L=1.0u
MN3652   0      #1578    #1594    0      MN1      W=    5.40u L=1.0u
MP3651   #1551    #1593    #1517    1      MP1      W=    5.40u L=1.0u
MP3650   #1550    #1592    #1593    1      MP1      W=    5.40u L=1.0u
MP3649   #1549    #1591    #1592    1      MP1      W=    5.40u L=1.0u
MP3648   #1548    #1590    #1591    1      MP1      W=    5.40u L=1.0u
MP3647   #1547    #1589    #1590    1      MP1      W=    5.40u L=1.0u
MP3646   #1546    #1588    #1589    1      MP1      W=    5.40u L=1.0u
MP3645   #1545    #1587    #1588    1      MP1      W=    5.40u L=1.0u
MP3644   #1544    #1586    #1587    1      MP1      W=    5.40u L=1.0u
MP3643   #1543    #1585    #1586    1      MP1      W=    5.40u L=1.0u
MP3642   #1542    #1584    #1585    1      MP1      W=    5.40u L=1.0u
MP3641   #1541    #1583    #1584    1      MP1      W=    5.40u L=1.0u
MP3640   #1540    #1582    #1583    1      MP1      W=    5.40u L=1.0u
MP3639   #1539    #1581    #1582    1      MP1      W=    5.40u L=1.0u
MP3638   #1538    #1580    #1581    1      MP1      W=    5.40u L=1.0u
MP3637   #1537    #1429    #1580    1      MP1      W=    5.40u L=1.0u
MN3636   #1536    #1593    #1517    0      MN1      W=    5.40u L=1.0u
MN3635   #1535    #1592    #1593    0      MN1      W=    5.40u L=1.0u
MN3634   #1534    #1591    #1592    0      MN1      W=    5.40u L=1.0u
MN3633   #1533    #1590    #1591    0      MN1      W=    5.40u L=1.0u
MN3632   #1532    #1589    #1590    0      MN1      W=    5.40u L=1.0u
MN3631   #1531    #1588    #1589    0      MN1      W=    5.40u L=1.0u
MN3630   #1530    #1587    #1588    0      MN1      W=    5.40u L=1.0u
MN3629   #1529    #1586    #1587    0      MN1      W=    5.40u L=1.0u
MN3628   #1528    #1585    #1586    0      MN1      W=    5.40u L=1.0u
MN3627   #1527    #1584    #1585    0      MN1      W=    5.40u L=1.0u
MN3626   #1526    #1583    #1584    0      MN1      W=    5.40u L=1.0u
MN3625   #1525    #1582    #1583    0      MN1      W=    5.40u L=1.0u
MN3624   #1524    #1581    #1582    0      MN1      W=    5.40u L=1.0u
MN3623   #1523    #1580    #1581    0      MN1      W=    5.40u L=1.0u
MN3622   #1522    #1429    #1580    0      MN1      W=    5.40u L=1.0u
MP3621   #1579    #1575    1      1      MP1      W=    5.40u L=1.0u
MP3619   1      X8       #1559    1      MP1      W=   10.80u L=1.0u
MN3618   #1577    X8       #1559    0      MN1      W=    3.60u L=1.0u
MN3617   #1578    #1575    0      0      MN1      W=    5.40u L=1.0u
MP3616   #1578    #1575    1      1      MP1      W=    5.40u L=1.0u
MN3615   0      #1574    #1536    0      MN1      W=   16.20u L=1.0u
MP3614   1      #1574    #1551    1      MP1      W=   16.20u L=1.0u
MP3613   1      #1573    #1550    1      MP1      W=   16.20u L=1.0u
MN3612   0      #1573    #1535    0      MN1      W=   16.20u L=1.0u
MN3611   0      #1572    #1534    0      MN1      W=   16.20u L=1.0u
MP3610   1      #1572    #1549    1      MP1      W=   16.20u L=1.0u
MP3609   1      #1571    #1548    1      MP1      W=   16.20u L=1.0u
MN3608   0      #1571    #1533    0      MN1      W=   16.20u L=1.0u
MN3607   0      #1570    #1532    0      MN1      W=   16.20u L=1.0u
MP3606   1      #1570    #1547    1      MP1      W=   16.20u L=1.0u
MP3605   1      #1569    #1546    1      MP1      W=   16.20u L=1.0u
MN3604   0      #1569    #1531    0      MN1      W=   16.20u L=1.0u
MN3603   0      #1568    #1530    0      MN1      W=   16.20u L=1.0u
MP3602   1      #1568    #1545    1      MP1      W=   16.20u L=1.0u
MP3601   1      #1567    #1544    1      MP1      W=   16.20u L=1.0u
MN3600   0      #1567    #1529    0      MN1      W=   16.20u L=1.0u
MN3599   0      #1566    #1528    0      MN1      W=   16.20u L=1.0u
MP3598   1      #1566    #1543    1      MP1      W=   16.20u L=1.0u
MP3597   1      #1565    #1542    1      MP1      W=   16.20u L=1.0u
MN3596   0      #1565    #1527    0      MN1      W=   16.20u L=1.0u
MN3595   0      #1564    #1526    0      MN1      W=   16.20u L=1.0u
MP3594   1      #1564    #1541    1      MP1      W=   16.20u L=1.0u
MP3593   1      #1563    #1540    1      MP1      W=   16.20u L=1.0u
MN3592   0      #1563    #1525    0      MN1      W=   16.20u L=1.0u
MN3591   0      #1562    #1524    0      MN1      W=   16.20u L=1.0u
MP3590   1      #1562    #1539    1      MP1      W=   16.20u L=1.0u
MP3589   1      #1561    #1538    1      MP1      W=   16.20u L=1.0u
MN3588   0      #1561    #1523    0      MN1      W=   16.20u L=1.0u
MN3587   0      #1560    #1522    0      MN1      W=   16.20u L=1.0u
MP3586   1      #1560    #1537    1      MP1      W=   16.20u L=1.0u
MP3584   #1170    #1333    #1579    1      MP1      W=    5.40u L=1.0u
MN3583   0      X9       #1577    0      MN1      W=    3.60u L=1.0u
MP3552   #1553    #1558    #1170    1      MP1      W=    5.40u L=1.0u
MN3550   #1575    #1517    0      0      MN1      W=    5.40u L=1.0u
MP3549   #1576    #1517    #1575    1      MP1      W=    5.40u L=1.0u
MP3533   1      #1559    #1410    1      MP1      W=   10.80u L=1.0u
MN3517   #1557    #1559    0      0      MN1      W=    3.60u L=1.0u
MP3515   1      #1340    #1576    1      MP1      W=    5.40u L=1.0u
MN3514   #1170    #1558    #1521    0      MN1      W=    5.40u L=1.0u
MN3513   0      #1340    #1575    0      MN1      W=    5.40u L=1.0u
MN3512   #1518    #1342    #1557    0      MN1      W=    3.60u L=1.0u
MP3511   #1410    #1342    1      1      MP1      W=   10.80u L=1.0u
MP3509   #1520    #1340    1      1      MP1      W=    5.40u L=1.0u
MN3508   #1554    #1340    0      0      MN1      W=    5.40u L=1.0u
MN3507   #1536    #1332    0      0      MN1      W=   10.80u L=1.0u
MN3506   #1535    #1339    0      0      MN1      W=   10.80u L=1.0u
MN3505   #1534    #1331    0      0      MN1      W=   10.80u L=1.0u
MN3504   #1533    #1338    0      0      MN1      W=   10.80u L=1.0u
MN3503   #1532    #1330    0      0      MN1      W=   10.80u L=1.0u
MN3502   #1531    #1337    0      0      MN1      W=   10.80u L=1.0u
MN3501   #1530    #1329    0      0      MN1      W=   10.80u L=1.0u
MN3500   #1529    #1336    0      0      MN1      W=   10.80u L=1.0u
MN3499   #1528    #1328    0      0      MN1      W=   10.80u L=1.0u
MN3498   #1527    #1335    0      0      MN1      W=   10.80u L=1.0u
MN3497   #1526    #1327    0      0      MN1      W=   10.80u L=1.0u
MN3496   #1525    #1334    0      0      MN1      W=   10.80u L=1.0u
MN3495   #1524    #1326    0      0      MN1      W=   10.80u L=1.0u
MN3494   #1523    #1428    0      0      MN1      W=   10.80u L=1.0u
MN3493   #1522    #1430    0      0      MN1      W=   10.80u L=1.0u
MN3492   #1555    #1520    #1170    0      MN1      W=    1.80u L=1.0u
MP3491   #1551    #1332    1      1      MP1      W=   10.80u L=1.0u
MP3490   #1550    #1339    1      1      MP1      W=   10.80u L=1.0u
MP3489   #1549    #1331    1      1      MP1      W=   10.80u L=1.0u
MP3488   #1548    #1338    1      1      MP1      W=   10.80u L=1.0u
MP3487   #1547    #1330    1      1      MP1      W=   10.80u L=1.0u
MP3486   #1546    #1337    1      1      MP1      W=   10.80u L=1.0u
MP3485   #1545    #1329    1      1      MP1      W=   10.80u L=1.0u
MP3484   #1544    #1336    1      1      MP1      W=   10.80u L=1.0u
MP3483   #1543    #1328    1      1      MP1      W=   10.80u L=1.0u
MP3482   #1542    #1335    1      1      MP1      W=   10.80u L=1.0u
MP3481   #1541    #1327    1      1      MP1      W=   10.80u L=1.0u
MP3480   #1540    #1334    1      1      MP1      W=   10.80u L=1.0u
MP3479   #1539    #1326    1      1      MP1      W=   10.80u L=1.0u
MP3478   #1538    #1428    1      1      MP1      W=   10.80u L=1.0u
MP3477   #1537    #1430    1      1      MP1      W=   10.80u L=1.0u
MN3476   #1410    X8       #1518    0      MN1      W=    3.60u L=1.0u
MP3475   #1552    X8       #1410    1      MP1      W=   10.80u L=1.0u
MN3474   #1521    #1333    #1555    0      MN1      W=    1.80u L=1.0u
MN3473   #1520    #1517    #1554    0      MN1      W=    5.40u L=1.0u
MP3471   1      #1517    #1520    1      MP1      W=    5.40u L=1.0u
MP3470   1      X9       #1552    1      MP1      W=   10.80u L=1.0u
MN3439   #1518    X9       #1410    0      MN1      W=    3.60u L=1.0u
MN3438   0      #1376    #1447    0      MN1      W=    3.60u L=1.0u
MN3437   0      #1375    #1439    0      MN1      W=    3.60u L=1.0u
MN3436   0      #1391    #1446    0      MN1      W=    3.60u L=1.0u
MN3435   0      #1390    #1437    0      MN1      W=    3.60u L=1.0u
MN3434   0      #1389    #1445    0      MN1      W=    3.60u L=1.0u
MN3433   0      #1388    #1436    0      MN1      W=    3.60u L=1.0u
MN3432   0      #1387    #1444    0      MN1      W=    3.60u L=1.0u
MN3431   0      #1386    #1435    0      MN1      W=    3.60u L=1.0u
MN3430   0      #1385    #1443    0      MN1      W=    3.60u L=1.0u
MN3429   0      #1384    #1434    0      MN1      W=    3.60u L=1.0u
MN3428   0      #1383    #1442    0      MN1      W=    3.60u L=1.0u
MN3427   0      #1382    #1433    0      MN1      W=    3.60u L=1.0u
MN3426   0      #1381    #1441    0      MN1      W=    3.60u L=1.0u
MN3425   0      #1380    #1432    0      MN1      W=    3.60u L=1.0u
MN3424   0      #1379    #1440    0      MN1      W=    3.60u L=1.0u
MP3423   1      #1376    #1447    1      MP1      W=    3.60u L=1.0u
MP3422   1      #1375    #1439    1      MP1      W=    3.60u L=1.0u
MP3421   1      #1391    #1446    1      MP1      W=    3.60u L=1.0u
MP3420   1      #1390    #1437    1      MP1      W=    3.60u L=1.0u
MP3419   1      #1389    #1445    1      MP1      W=    3.60u L=1.0u
MP3418   1      #1388    #1436    1      MP1      W=    3.60u L=1.0u
MP3417   1      #1387    #1444    1      MP1      W=    3.60u L=1.0u
MP3416   1      #1386    #1435    1      MP1      W=    3.60u L=1.0u
MP3415   1      #1385    #1443    1      MP1      W=    3.60u L=1.0u
MP3414   1      #1384    #1434    1      MP1      W=    3.60u L=1.0u
MP3413   1      #1383    #1442    1      MP1      W=    3.60u L=1.0u
MP3412   1      #1382    #1433    1      MP1      W=    3.60u L=1.0u
MP3411   1      #1381    #1441    1      MP1      W=    3.60u L=1.0u
MP3410   1      #1380    #1432    1      MP1      W=    3.60u L=1.0u
MP3409   1      #1379    #1440    1      MP1      W=    3.60u L=1.0u
MP3408   1      #1378    #1431    1      MP1      W=    3.60u L=1.0u
MN3407   0      #1378    #1431    0      MN1      W=    3.60u L=1.0u
MP3406   1      #1392    #1438    1      MP1      W=    3.60u L=1.0u
MP3405   #1482    #1430    1      1      MP1      W=   21.60u L=1.0u
MN3404   0      #1392    #1438    0      MN1      W=    3.60u L=1.0u
MN3403   #1482    #1430    0      0      MN1      W=    7.20u L=1.0u
MP3400   #1516    #1447    1      1      MP1      W=    3.60u L=1.0u
MP3399   #1515    #1439    1      1      MP1      W=    3.60u L=1.0u
MP3398   #1514    #1391    1      1      MP1      W=    3.60u L=1.0u
MP3397   #1513    #1437    1      1      MP1      W=    3.60u L=1.0u
MP3396   #1512    #1389    1      1      MP1      W=    3.60u L=1.0u
MP3395   #1511    #1436    1      1      MP1      W=    3.60u L=1.0u
MP3394   #1510    #1387    1      1      MP1      W=    3.60u L=1.0u
MP3393   #1509    #1435    1      1      MP1      W=    3.60u L=1.0u
MP3392   #1508    #1385    1      1      MP1      W=    3.60u L=1.0u
MP3391   #1507    #1434    1      1      MP1      W=    3.60u L=1.0u
MP3390   #1506    #1383    1      1      MP1      W=    3.60u L=1.0u
MP3389   #1505    #1433    1      1      MP1      W=    3.60u L=1.0u
MP3388   #1504    #1381    1      1      MP1      W=    3.60u L=1.0u
MP3387   #1503    #1432    1      1      MP1      W=    3.60u L=1.0u
MP3386   #1502    #1379    1      1      MP1      W=    3.60u L=1.0u
MP3385   #1501    #1431    1      1      MP1      W=    3.60u L=1.0u
MP3384   #1500    #1392    1      1      MP1      W=    3.60u L=1.0u
MN3383   #1499    #1376    0      0      MN1      W=    3.60u L=1.0u
MN3382   #1498    #1375    0      0      MN1      W=    3.60u L=1.0u
MN3381   #1497    #1446    0      0      MN1      W=    3.60u L=1.0u
MN3380   #1496    #1390    0      0      MN1      W=    3.60u L=1.0u
MN3379   #1495    #1445    0      0      MN1      W=    3.60u L=1.0u
MN3378   #1494    #1388    0      0      MN1      W=    3.60u L=1.0u
MN3377   #1493    #1444    0      0      MN1      W=    3.60u L=1.0u
MN3376   #1492    #1386    0      0      MN1      W=    3.60u L=1.0u
MN3375   #1491    #1443    0      0      MN1      W=    3.60u L=1.0u
MN3374   #1490    #1384    0      0      MN1      W=    3.60u L=1.0u
MN3373   #1489    #1442    0      0      MN1      W=    3.60u L=1.0u
MN3372   #1488    #1382    0      0      MN1      W=    3.60u L=1.0u
MN3371   #1487    #1441    0      0      MN1      W=    3.60u L=1.0u
MN3370   #1486    #1380    0      0      MN1      W=    3.60u L=1.0u
MN3369   #1485    #1440    0      0      MN1      W=    3.60u L=1.0u
MN3368   #1484    #1378    0      0      MN1      W=    3.60u L=1.0u
MN3367   #1483    #1438    0      0      MN1      W=    3.60u L=1.0u
MP3366   #1426    #1482    #1516    1      MP1      W=    3.60u L=1.0u
MP3365   #1425    #1482    #1515    1      MP1      W=    3.60u L=1.0u
MP3364   #1424    #1482    #1514    1      MP1      W=    3.60u L=1.0u
MP3363   #1423    #1482    #1513    1      MP1      W=    3.60u L=1.0u
MP3362   #1422    #1482    #1512    1      MP1      W=    3.60u L=1.0u
MP3361   #1421    #1482    #1511    1      MP1      W=    3.60u L=1.0u
MP3360   #1420    #1482    #1510    1      MP1      W=    3.60u L=1.0u
MP3359   #1419    #1482    #1509    1      MP1      W=    3.60u L=1.0u
MP3358   #1418    #1482    #1508    1      MP1      W=    3.60u L=1.0u
MP3357   #1417    #1482    #1507    1      MP1      W=    3.60u L=1.0u
MP3356   #1416    #1482    #1506    1      MP1      W=    3.60u L=1.0u
MP3355   #1415    #1482    #1505    1      MP1      W=    3.60u L=1.0u
MP3354   #1414    #1482    #1504    1      MP1      W=    3.60u L=1.0u
MP3353   #1413    #1482    #1503    1      MP1      W=    3.60u L=1.0u
MP3352   #1412    #1482    #1502    1      MP1      W=    3.60u L=1.0u
MP3351   #1411    #1482    #1501    1      MP1      W=    3.60u L=1.0u
MN3350   #1426    #1482    #1499    0      MN1      W=    3.60u L=1.0u
MN3349   #1425    #1482    #1498    0      MN1      W=    3.60u L=1.0u
MN3348   #1424    #1482    #1497    0      MN1      W=    3.60u L=1.0u
MN3347   #1423    #1482    #1496    0      MN1      W=    3.60u L=1.0u
MN3346   #1422    #1482    #1495    0      MN1      W=    3.60u L=1.0u
MN3345   #1421    #1482    #1494    0      MN1      W=    3.60u L=1.0u
MN3344   #1420    #1482    #1493    0      MN1      W=    3.60u L=1.0u
MN3343   #1419    #1482    #1492    0      MN1      W=    3.60u L=1.0u
MN3342   #1418    #1482    #1491    0      MN1      W=    3.60u L=1.0u
MN3341   #1417    #1482    #1490    0      MN1      W=    3.60u L=1.0u
MN3340   #1416    #1482    #1489    0      MN1      W=    3.60u L=1.0u
MN3339   #1415    #1482    #1488    0      MN1      W=    3.60u L=1.0u
MN3338   #1414    #1482    #1487    0      MN1      W=    3.60u L=1.0u
MN3337   #1413    #1482    #1486    0      MN1      W=    3.60u L=1.0u
MN3336   #1412    #1482    #1485    0      MN1      W=    3.60u L=1.0u
MN3335   #1411    #1482    #1484    0      MN1      W=    3.60u L=1.0u
MP3334   #1427    #1482    #1500    1      MP1      W=    3.60u L=1.0u
MN3333   #1427    #1482    #1483    0      MN1      W=    3.60u L=1.0u
MP3332   #1430    X9       1      1      MP1      W=   21.60u L=1.0u
MN3331   #1430    X9       0      0      MN1      W=    7.20u L=1.0u
MN3330   #1464    #1430    #1426    0      MN1      W=    3.60u L=1.0u
MP3329   #1481    #1430    #1426    1      MP1      W=    3.60u L=1.0u
MP3328   #1479    #1430    #1425    1      MP1      W=    3.60u L=1.0u
MN3327   #1462    #1430    #1424    0      MN1      W=    3.60u L=1.0u
MP3326   #1478    #1430    #1424    1      MP1      W=    3.60u L=1.0u
MP3325   #1477    #1430    #1423    1      MP1      W=    3.60u L=1.0u
MN3324   #1460    #1430    #1422    0      MN1      W=    3.60u L=1.0u
MP3323   #1476    #1430    #1422    1      MP1      W=    3.60u L=1.0u
MP3322   #1475    #1430    #1421    1      MP1      W=    3.60u L=1.0u
MN3321   #1458    #1430    #1420    0      MN1      W=    3.60u L=1.0u
MP3320   #1474    #1430    #1420    1      MP1      W=    3.60u L=1.0u
MP3319   #1473    #1430    #1419    1      MP1      W=    3.60u L=1.0u
MN3318   #1456    #1430    #1418    0      MN1      W=    3.60u L=1.0u
MP3317   #1472    #1430    #1418    1      MP1      W=    3.60u L=1.0u
MP3316   #1471    #1430    #1417    1      MP1      W=    3.60u L=1.0u
MN3315   #1454    #1430    #1416    0      MN1      W=    3.60u L=1.0u
MP3314   #1470    #1430    #1416    1      MP1      W=    3.60u L=1.0u
MP3313   #1469    #1430    #1415    1      MP1      W=    3.60u L=1.0u
MN3312   #1452    #1430    #1414    0      MN1      W=    3.60u L=1.0u
MP3311   #1468    #1430    #1414    1      MP1      W=    3.60u L=1.0u
MP3310   #1467    #1430    #1413    1      MP1      W=    3.60u L=1.0u
MN3309   #1450    #1430    #1412    0      MN1      W=    3.60u L=1.0u
MP3308   #1466    #1430    #1412    1      MP1      W=    3.60u L=1.0u
MP3307   #1465    #1430    #1411    1      MP1      W=    3.60u L=1.0u
MN3306   #1449    #1430    #1411    0      MN1      W=    3.60u L=1.0u
MN3305   #1463    #1430    #1425    0      MN1      W=    3.60u L=1.0u
MN3304   #1461    #1430    #1423    0      MN1      W=    3.60u L=1.0u
MN3303   #1459    #1430    #1421    0      MN1      W=    3.60u L=1.0u
MN3302   #1457    #1430    #1419    0      MN1      W=    3.60u L=1.0u
MN3301   #1455    #1430    #1417    0      MN1      W=    3.60u L=1.0u
MN3300   #1453    #1430    #1415    0      MN1      W=    3.60u L=1.0u
MN3299   #1451    #1430    #1413    0      MN1      W=    3.60u L=1.0u
MN3298   #1448    #1430    #1427    0      MN1      W=    3.60u L=1.0u
MP3297   #1480    #1430    #1427    1      MP1      W=    3.60u L=1.0u
MP3294   1      #1376    #1481    1      MP1      W=    3.60u L=1.0u
MP3293   1      #1438    #1480    1      MP1      W=    3.60u L=1.0u
MN3292   0      #1447    #1464    0      MN1      W=    3.60u L=1.0u
MP3291   1      #1375    #1479    1      MP1      W=    3.60u L=1.0u
MN3290   0      #1439    #1463    0      MN1      W=    3.60u L=1.0u
MN3289   0      #1391    #1462    0      MN1      W=    3.60u L=1.0u
MP3288   1      #1446    #1478    1      MP1      W=    3.60u L=1.0u
MP3287   1      #1390    #1477    1      MP1      W=    3.60u L=1.0u
MN3286   0      #1437    #1461    0      MN1      W=    3.60u L=1.0u
MN3285   0      #1389    #1460    0      MN1      W=    3.60u L=1.0u
MP3284   1      #1445    #1476    1      MP1      W=    3.60u L=1.0u
MP3283   1      #1388    #1475    1      MP1      W=    3.60u L=1.0u
MN3282   0      #1436    #1459    0      MN1      W=    3.60u L=1.0u
MN3281   0      #1387    #1458    0      MN1      W=    3.60u L=1.0u
MP3280   1      #1444    #1474    1      MP1      W=    3.60u L=1.0u
MP3279   1      #1386    #1473    1      MP1      W=    3.60u L=1.0u
MN3278   0      #1435    #1457    0      MN1      W=    3.60u L=1.0u
MN3277   0      #1385    #1456    0      MN1      W=    3.60u L=1.0u
MP3276   1      #1443    #1472    1      MP1      W=    3.60u L=1.0u
MP3275   1      #1384    #1471    1      MP1      W=    3.60u L=1.0u
MN3274   0      #1434    #1455    0      MN1      W=    3.60u L=1.0u
MN3273   0      #1383    #1454    0      MN1      W=    3.60u L=1.0u
MP3272   1      #1442    #1470    1      MP1      W=    3.60u L=1.0u
MP3271   1      #1382    #1469    1      MP1      W=    3.60u L=1.0u
MN3270   0      #1433    #1453    0      MN1      W=    3.60u L=1.0u
MN3269   0      #1381    #1452    0      MN1      W=    3.60u L=1.0u
MP3268   1      #1441    #1468    1      MP1      W=    3.60u L=1.0u
MP3267   1      #1380    #1467    1      MP1      W=    3.60u L=1.0u
MN3266   0      #1432    #1451    0      MN1      W=    3.60u L=1.0u
MN3265   0      #1379    #1450    0      MN1      W=    3.60u L=1.0u
MP3264   1      #1440    #1466    1      MP1      W=    3.60u L=1.0u
MP3263   1      #1378    #1465    1      MP1      W=    3.60u L=1.0u
MN3262   0      #1431    #1449    0      MN1      W=    3.60u L=1.0u
MN3261   0      #1392    #1448    0      MN1      W=    3.60u L=1.0u
MN3260   #1377    #1410    0      0      MN1      W=   14.40u L=1.0u
MP3259   #1377    #1410    1      1      MP1      W=   43.20u L=1.0u
MP3258   #1429    #1427    1      1      MP1      W=   10.80u L=1.0u
MN3257   #1151    #1426    0      0      MN1      W=   10.80u L=1.0u
MN3256   #1150    #1425    0      0      MN1      W=   10.80u L=1.0u
MN3255   #1149    #1424    0      0      MN1      W=   10.80u L=1.0u
MN3254   #1148    #1423    0      0      MN1      W=   10.80u L=1.0u
MN3253   #1147    #1422    0      0      MN1      W=   10.80u L=1.0u
MN3252   #1146    #1421    0      0      MN1      W=   10.80u L=1.0u
MN3251   #1145    #1420    0      0      MN1      W=   10.80u L=1.0u
MN3250   #1144    #1419    0      0      MN1      W=   10.80u L=1.0u
MN3249   #1143    #1418    0      0      MN1      W=   10.80u L=1.0u
MN3248   #1142    #1417    0      0      MN1      W=   10.80u L=1.0u
MN3247   #1141    #1416    0      0      MN1      W=   10.80u L=1.0u
MN3246   #1140    #1415    0      0      MN1      W=   10.80u L=1.0u
MN3245   #1139    #1414    0      0      MN1      W=   10.80u L=1.0u
MN3244   #1138    #1413    0      0      MN1      W=   10.80u L=1.0u
MN3243   #1137    #1412    0      0      MN1      W=   10.80u L=1.0u
MN3242   #1428    #1411    0      0      MN1      W=   10.80u L=1.0u
MN3241   #1429    #1427    0      0      MN1      W=   10.80u L=1.0u
MP3240   #1151    #1426    1      1      MP1      W=   10.80u L=1.0u
MP3239   #1150    #1425    1      1      MP1      W=   10.80u L=1.0u
MP3238   #1149    #1424    1      1      MP1      W=   10.80u L=1.0u
MP3237   #1148    #1423    1      1      MP1      W=   10.80u L=1.0u
MP3236   #1147    #1422    1      1      MP1      W=   10.80u L=1.0u
MP3235   #1146    #1421    1      1      MP1      W=   10.80u L=1.0u
MP3234   #1145    #1420    1      1      MP1      W=   10.80u L=1.0u
MP3233   #1144    #1419    1      1      MP1      W=   10.80u L=1.0u
MP3232   #1143    #1418    1      1      MP1      W=   10.80u L=1.0u
MP3231   #1142    #1417    1      1      MP1      W=   10.80u L=1.0u
MP3230   #1141    #1416    1      1      MP1      W=   10.80u L=1.0u
MP3229   #1140    #1415    1      1      MP1      W=   10.80u L=1.0u
MP3228   #1139    #1414    1      1      MP1      W=   10.80u L=1.0u
MP3227   #1138    #1413    1      1      MP1      W=   10.80u L=1.0u
MP3226   #1137    #1412    1      1      MP1      W=   10.80u L=1.0u
MP3225   #1428    #1411    1      1      MP1      W=   10.80u L=1.0u
MP3186   #1344    #1377    1      1      MP1      W=    3.60u L=1.0u
MP3185   #1343    #1377    1      1      MP1      W=    3.60u L=1.0u
MP3184   #1359    #1377    1      1      MP1      W=    3.60u L=1.0u
MP3183   #1358    #1377    1      1      MP1      W=    3.60u L=1.0u
MP3182   #1357    #1377    1      1      MP1      W=    3.60u L=1.0u
MP3181   #1356    #1377    1      1      MP1      W=    3.60u L=1.0u
MP3180   #1355    #1377    1      1      MP1      W=    3.60u L=1.0u
MP3179   #1354    #1377    1      1      MP1      W=    3.60u L=1.0u
MP3178   #1353    #1377    1      1      MP1      W=    3.60u L=1.0u
MP3177   #1352    #1377    1      1      MP1      W=    3.60u L=1.0u
MP3176   #1351    #1377    1      1      MP1      W=    3.60u L=1.0u
MP3175   #1350    #1377    1      1      MP1      W=    3.60u L=1.0u
MP3174   #1349    #1377    1      1      MP1      W=    3.60u L=1.0u
MP3173   #1348    #1377    1      1      MP1      W=    3.60u L=1.0u
MP3172   #1347    #1377    1      1      MP1      W=    3.60u L=1.0u
MP3171   #1346    #1377    1      1      MP1      W=    3.60u L=1.0u
MP3170   #1392    #1341    1      1      MP1      W=    3.60u L=1.0u
MN3169   #1409    #1341    0      0      MN1      W=    3.60u L=1.0u
MN3168   #1408    #1341    0      0      MN1      W=    3.60u L=1.0u
MN3167   #1407    #1341    0      0      MN1      W=    3.60u L=1.0u
MN3166   #1406    #1341    0      0      MN1      W=    3.60u L=1.0u
MN3165   #1405    #1341    0      0      MN1      W=    3.60u L=1.0u
MN3164   #1404    #1341    0      0      MN1      W=    3.60u L=1.0u
MN3163   #1403    #1341    0      0      MN1      W=    3.60u L=1.0u
MN3162   #1402    #1341    0      0      MN1      W=    3.60u L=1.0u
MN3161   #1401    #1341    0      0      MN1      W=    3.60u L=1.0u
MN3160   #1400    #1341    0      0      MN1      W=    3.60u L=1.0u
MN3159   #1399    #1341    0      0      MN1      W=    3.60u L=1.0u
MN3158   #1398    #1341    0      0      MN1      W=    3.60u L=1.0u
MN3157   #1397    #1341    0      0      MN1      W=    3.60u L=1.0u
MN3156   #1396    #1341    0      0      MN1      W=    3.60u L=1.0u
MN3155   #1395    #1341    0      0      MN1      W=    3.60u L=1.0u
MN3154   #1394    #1341    0      0      MN1      W=    3.60u L=1.0u
MN3151   #1393    #1341    0      0      MN1      W=    3.60u L=1.0u
MP3150   #1391    #51      #1359    1      MP1      W=    3.60u L=1.0u
MP3149   #1390    #50      #1358    1      MP1      W=    3.60u L=1.0u
MP3148   #1389    #49      #1357    1      MP1      W=    3.60u L=1.0u
MP3147   #1388    #48      #1356    1      MP1      W=    3.60u L=1.0u
MP3146   #1387    #47      #1355    1      MP1      W=    3.60u L=1.0u
MP3145   #1386    #46      #1354    1      MP1      W=    3.60u L=1.0u
MP3144   #1385    #45      #1353    1      MP1      W=    3.60u L=1.0u
MP3143   #1384    #44      #1352    1      MP1      W=    3.60u L=1.0u
MP3142   #1383    #43      #1351    1      MP1      W=    3.60u L=1.0u
MP3141   #1382    #42      #1350    1      MP1      W=    3.60u L=1.0u
MP3140   #1381    #41      #1349    1      MP1      W=    3.60u L=1.0u
MP3139   #1380    #40      #1348    1      MP1      W=    3.60u L=1.0u
MP3138   #1379    #39      #1347    1      MP1      W=    3.60u L=1.0u
MP3137   #1378    #38      #1346    1      MP1      W=    3.60u L=1.0u
MN3136   #1375    #52      #1409    0      MN1      W=    3.60u L=1.0u
MN3135   #1391    #51      #1408    0      MN1      W=    3.60u L=1.0u
MN3134   #1390    #50      #1407    0      MN1      W=    3.60u L=1.0u
MN3133   #1389    #49      #1406    0      MN1      W=    3.60u L=1.0u
MN3132   #1388    #48      #1405    0      MN1      W=    3.60u L=1.0u
MN3131   #1387    #47      #1404    0      MN1      W=    3.60u L=1.0u
MN3130   #1386    #46      #1403    0      MN1      W=    3.60u L=1.0u
MN3129   #1385    #45      #1402    0      MN1      W=    3.60u L=1.0u
MN3128   #1384    #44      #1401    0      MN1      W=    3.60u L=1.0u
MN3127   #1383    #43      #1400    0      MN1      W=    3.60u L=1.0u
MN3126   #1382    #42      #1399    0      MN1      W=    3.60u L=1.0u
MN3125   #1381    #41      #1398    0      MN1      W=    3.60u L=1.0u
MN3124   #1380    #40      #1397    0      MN1      W=    3.60u L=1.0u
MN3123   #1379    #39      #1396    0      MN1      W=    3.60u L=1.0u
MN3122   #1378    #38      #1395    0      MN1      W=    3.60u L=1.0u
MN3121   #1392    #37      #1394    0      MN1      W=    3.60u L=1.0u
MP3120   1      #37      #1392    1      MP1      W=    3.60u L=1.0u
MP3119   #1375    #52      #1343    1      MP1      W=    3.60u L=1.0u
MP3118   #1376    #52      #1344    1      MP1      W=    3.60u L=1.0u
MN3117   #1341    #1342    0      0      MN1      W=   14.40u L=1.0u
MN3116   #1376    #52      #1393    0      MN1      W=    3.60u L=1.0u
MP3115   #1341    #1342    1      1      MP1      W=   43.20u L=1.0u
MN3114   #1374    #1377    #1375    0      MN1      W=    3.60u L=1.0u
MN3113   #1373    #1377    #1391    0      MN1      W=    3.60u L=1.0u
MN3112   #1372    #1377    #1390    0      MN1      W=    3.60u L=1.0u
MN3111   #1371    #1377    #1389    0      MN1      W=    3.60u L=1.0u
MN3110   #1370    #1377    #1388    0      MN1      W=    3.60u L=1.0u
MN3109   #1369    #1377    #1387    0      MN1      W=    3.60u L=1.0u
MN3108   #1368    #1377    #1386    0      MN1      W=    3.60u L=1.0u
MN3107   #1367    #1377    #1385    0      MN1      W=    3.60u L=1.0u
MN3106   #1366    #1377    #1384    0      MN1      W=    3.60u L=1.0u
MN3105   #1365    #1377    #1383    0      MN1      W=    3.60u L=1.0u
MN3104   #1364    #1377    #1382    0      MN1      W=    3.60u L=1.0u
MN3103   #1363    #1377    #1381    0      MN1      W=    3.60u L=1.0u
MN3102   #1362    #1377    #1380    0      MN1      W=    3.60u L=1.0u
MN3101   #1361    #1377    #1379    0      MN1      W=    3.60u L=1.0u
MP3100   #1359    #1341    #1391    1      MP1      W=    3.60u L=1.0u
MP3099   #1358    #1341    #1390    1      MP1      W=    3.60u L=1.0u
MP3098   #1357    #1341    #1389    1      MP1      W=    3.60u L=1.0u
MP3097   #1356    #1341    #1388    1      MP1      W=    3.60u L=1.0u
MP3096   #1355    #1341    #1387    1      MP1      W=    3.60u L=1.0u
MP3095   #1354    #1341    #1386    1      MP1      W=    3.60u L=1.0u
MP3094   #1353    #1341    #1385    1      MP1      W=    3.60u L=1.0u
MP3093   #1352    #1341    #1384    1      MP1      W=    3.60u L=1.0u
MP3092   #1351    #1341    #1383    1      MP1      W=    3.60u L=1.0u
MP3091   #1350    #1341    #1382    1      MP1      W=    3.60u L=1.0u
MP3090   #1349    #1341    #1381    1      MP1      W=    3.60u L=1.0u
MP3089   #1348    #1341    #1380    1      MP1      W=    3.60u L=1.0u
MP3088   #1347    #1341    #1379    1      MP1      W=    3.60u L=1.0u
MP3087   #1346    #1341    #1378    1      MP1      W=    3.60u L=1.0u
MN3086   #1360    #1377    #1378    0      MN1      W=    3.60u L=1.0u
MN3085   #1345    #1377    #1376    0      MN1      W=    3.60u L=1.0u
MP3082   #1344    #1341    #1376    1      MP1      W=    3.60u L=1.0u
MP3081   #1343    #1341    #1375    1      MP1      W=    3.60u L=1.0u
MN3080   0      #51      #1374    0      MN1      W=    3.60u L=1.0u
MN3079   0      #50      #1373    0      MN1      W=    3.60u L=1.0u
MN3078   0      #49      #1372    0      MN1      W=    3.60u L=1.0u
MN3077   0      #48      #1371    0      MN1      W=    3.60u L=1.0u
MN3076   0      #47      #1370    0      MN1      W=    3.60u L=1.0u
MN3075   0      #46      #1369    0      MN1      W=    3.60u L=1.0u
MN3074   0      #45      #1368    0      MN1      W=    3.60u L=1.0u
MN3073   0      #44      #1367    0      MN1      W=    3.60u L=1.0u
MN3072   0      #43      #1366    0      MN1      W=    3.60u L=1.0u
MN3071   0      #42      #1365    0      MN1      W=    3.60u L=1.0u
MN3070   0      #41      #1364    0      MN1      W=    3.60u L=1.0u
MN3069   0      #40      #1363    0      MN1      W=    3.60u L=1.0u
MN3068   0      #39      #1362    0      MN1      W=    3.60u L=1.0u
MN3067   0      #38      #1361    0      MN1      W=    3.60u L=1.0u
MN3066   0      #37      #1360    0      MN1      W=    3.60u L=1.0u
MP3065   1      #50      #1359    1      MP1      W=    3.60u L=1.0u
MP3064   1      #49      #1358    1      MP1      W=    3.60u L=1.0u
MP3063   1      #48      #1357    1      MP1      W=    3.60u L=1.0u
MP3062   1      #47      #1356    1      MP1      W=    3.60u L=1.0u
MP3061   1      #46      #1355    1      MP1      W=    3.60u L=1.0u
MP3060   1      #45      #1354    1      MP1      W=    3.60u L=1.0u
MP3059   1      #44      #1353    1      MP1      W=    3.60u L=1.0u
MP3058   1      #43      #1352    1      MP1      W=    3.60u L=1.0u
MP3057   1      #42      #1351    1      MP1      W=    3.60u L=1.0u
MP3056   1      #41      #1350    1      MP1      W=    3.60u L=1.0u
MP3055   1      #40      #1349    1      MP1      W=    3.60u L=1.0u
MP3054   1      #39      #1348    1      MP1      W=    3.60u L=1.0u
MP3053   1      #38      #1347    1      MP1      W=    3.60u L=1.0u
MP3052   1      #37      #1346    1      MP1      W=    3.60u L=1.0u
MN3051   0      #52      #1345    0      MN1      W=    3.60u L=1.0u
MP3050   1      #52      #1344    1      MP1      W=    3.60u L=1.0u
MP3049   1      #51      #1343    1      MP1      W=    3.60u L=1.0u
MN3046   #1326    #1243    0      0      MN1      W=   10.80u L=1.0u
MP3045   #1326    #1243    1      1      MP1      W=   10.80u L=1.0u
MN3044   #1333    #1250    0      0      MN1      W=   10.80u L=1.0u
MN3043   #1340    #1257    0      0      MN1      W=   10.80u L=1.0u
MN3042   #1332    #1249    0      0      MN1      W=   10.80u L=1.0u
MN3041   #1339    #1256    0      0      MN1      W=   10.80u L=1.0u
MN3040   #1331    #1248    0      0      MN1      W=   10.80u L=1.0u
MN3039   #1338    #1255    0      0      MN1      W=   10.80u L=1.0u
MN3038   #1330    #1247    0      0      MN1      W=   10.80u L=1.0u
MN3037   #1337    #1254    0      0      MN1      W=   10.80u L=1.0u
MN3036   #1329    #1246    0      0      MN1      W=   10.80u L=1.0u
MN3035   #1336    #1253    0      0      MN1      W=   10.80u L=1.0u
MN3034   #1328    #1245    0      0      MN1      W=   10.80u L=1.0u
MN3033   #1335    #1252    0      0      MN1      W=   10.80u L=1.0u
MN3032   #1327    #1244    0      0      MN1      W=   10.80u L=1.0u
MN3031   #1334    #1251    0      0      MN1      W=   10.80u L=1.0u
MP3030   #1333    #1250    1      1      MP1      W=   10.80u L=1.0u
MP3029   #1340    #1257    1      1      MP1      W=   10.80u L=1.0u
MP3028   #1332    #1249    1      1      MP1      W=   10.80u L=1.0u
MP3027   #1339    #1256    1      1      MP1      W=   10.80u L=1.0u
MP3026   #1331    #1248    1      1      MP1      W=   10.80u L=1.0u
MP3025   #1338    #1255    1      1      MP1      W=   10.80u L=1.0u
MP3024   #1330    #1247    1      1      MP1      W=   10.80u L=1.0u
MP3023   #1337    #1254    1      1      MP1      W=   10.80u L=1.0u
MP3022   #1329    #1246    1      1      MP1      W=   10.80u L=1.0u
MP3021   #1336    #1253    1      1      MP1      W=   10.80u L=1.0u
MP3020   #1328    #1245    1      1      MP1      W=   10.80u L=1.0u
MP3019   #1335    #1252    1      1      MP1      W=   10.80u L=1.0u
MP3018   #1327    #1244    1      1      MP1      W=   10.80u L=1.0u
MP3017   #1334    #1251    1      1      MP1      W=   10.80u L=1.0u
MN2998   0      #1170    #1306    0      MN1      W=    1.80u L=1.0u
MN2983   Z25      #1258    0      0      MN1      W=    3.60u L=1.0u
MP2982   #1325    #1171    1      1      MP1      W=    1.80u L=1.0u
MP2981   Z25      #1258    1      1      MP1      W=    3.60u L=1.0u
MN2980   #1291    #1137    0      0      MN1      W=    5.40u L=1.0u
MP2979   #1322    #1137    1      1      MP1      W=    5.40u L=1.0u
MN2978   #1306    #1171    0      0      MN1      W=    1.80u L=1.0u
MN2977   #1305    #1151    0      0      MN1      W=    5.40u L=1.0u
MN2976   #1303    #1149    0      0      MN1      W=    5.40u L=1.0u
MN2975   #1301    #1147    0      0      MN1      W=    5.40u L=1.0u
MN2974   #1299    #1145    0      0      MN1      W=    5.40u L=1.0u
MN2973   #1297    #1143    0      0      MN1      W=    5.40u L=1.0u
MN2972   #1295    #1141    0      0      MN1      W=    5.40u L=1.0u
MN2971   #1293    #1139    0      0      MN1      W=    5.40u L=1.0u
MP2970   #1321    #1151    1      1      MP1      W=    5.40u L=1.0u
MP2969   #1319    #1149    1      1      MP1      W=    5.40u L=1.0u
MP2968   #1317    #1147    1      1      MP1      W=    5.40u L=1.0u
MP2967   #1315    #1145    1      1      MP1      W=    5.40u L=1.0u
MP2966   #1313    #1143    1      1      MP1      W=    5.40u L=1.0u
MP2965   #1311    #1141    1      1      MP1      W=    5.40u L=1.0u
MP2964   #1309    #1139    1      1      MP1      W=    5.40u L=1.0u
MP2963   #1323    #908     1      1      MP1      W=    5.40u L=1.0u
MP2962   #1258    #1170    #1325    1      MP1      W=    1.80u L=1.0u
MP2961   #1320    #1150    1      1      MP1      W=    5.40u L=1.0u
MP2960   #1318    #1148    1      1      MP1      W=    5.40u L=1.0u
MP2959   #1316    #1146    1      1      MP1      W=    5.40u L=1.0u
MP2958   #1314    #1144    1      1      MP1      W=    5.40u L=1.0u
MP2957   #1312    #1142    1      1      MP1      W=    5.40u L=1.0u
MP2956   #1310    #1140    1      1      MP1      W=    5.40u L=1.0u
MP2955   #1308    #1138    1      1      MP1      W=    5.40u L=1.0u
MN2954   #1304    #1150    0      0      MN1      W=    5.40u L=1.0u
MN2953   #1302    #1148    0      0      MN1      W=    5.40u L=1.0u
MN2952   #1300    #1146    0      0      MN1      W=    5.40u L=1.0u
MN2951   #1298    #1144    0      0      MN1      W=    5.40u L=1.0u
MN2950   #1296    #1142    0      0      MN1      W=    5.40u L=1.0u
MN2949   #1294    #1140    0      0      MN1      W=    5.40u L=1.0u
MN2948   #1292    #1138    0      0      MN1      W=    5.40u L=1.0u
MN2947   #1307    #908     0      0      MN1      W=    5.40u L=1.0u
MP2946   #1290    #1134    #1323    1      MP1      W=    5.40u L=1.0u
MP2945   #1288    #1005    #1322    1      MP1      W=    5.40u L=1.0u
MP2944   #1287    #907     #1321    1      MP1      W=    5.40u L=1.0u
MP2943   #1286    #914     #1320    1      MP1      W=    5.40u L=1.0u
MP2942   #1285    #906     #1319    1      MP1      W=    5.40u L=1.0u
MP2941   #1284    #913     #1318    1      MP1      W=    5.40u L=1.0u
MP2940   #1283    #905     #1317    1      MP1      W=    5.40u L=1.0u
MP2939   #1282    #912     #1316    1      MP1      W=    5.40u L=1.0u
MP2938   #1281    #904     #1315    1      MP1      W=    5.40u L=1.0u
MP2937   #1280    #911     #1314    1      MP1      W=    5.40u L=1.0u
MP2936   #1279    #903     #1313    1      MP1      W=    5.40u L=1.0u
MP2935   #1278    #910     #1312    1      MP1      W=    5.40u L=1.0u
MP2934   #1277    #902     #1311    1      MP1      W=    5.40u L=1.0u
MP2933   #1276    #909     #1310    1      MP1      W=    5.40u L=1.0u
MP2932   #1275    #901     #1309    1      MP1      W=    5.40u L=1.0u
MP2931   #1274    #1003    #1308    1      MP1      W=    5.40u L=1.0u
MN2930   #1289    #1134    #1307    0      MN1      W=    5.40u L=1.0u
MN2929   #1258    #1240    #1306    0      MN1      W=    1.80u L=1.0u
MN2928   #1273    #907     #1305    0      MN1      W=    5.40u L=1.0u
MN2927   #1272    #914     #1304    0      MN1      W=    5.40u L=1.0u
MN2926   #1271    #906     #1303    0      MN1      W=    5.40u L=1.0u
MN2925   #1270    #913     #1302    0      MN1      W=    5.40u L=1.0u
MN2924   #1269    #905     #1301    0      MN1      W=    5.40u L=1.0u
MN2923   #1268    #912     #1300    0      MN1      W=    5.40u L=1.0u
MN2922   #1267    #904     #1299    0      MN1      W=    5.40u L=1.0u
MN2921   #1266    #911     #1298    0      MN1      W=    5.40u L=1.0u
MN2920   #1265    #903     #1297    0      MN1      W=    5.40u L=1.0u
MN2919   #1264    #910     #1296    0      MN1      W=    5.40u L=1.0u
MN2918   #1263    #902     #1295    0      MN1      W=    5.40u L=1.0u
MN2917   #1262    #909     #1294    0      MN1      W=    5.40u L=1.0u
MN2916   #1261    #901     #1293    0      MN1      W=    5.40u L=1.0u
MN2915   #1260    #1003    #1292    0      MN1      W=    5.40u L=1.0u
MN2914   #1259    #1005    #1291    0      MN1      W=    5.40u L=1.0u
MP2913   1      #1240    #1258    1      MP1      W=    1.80u L=1.0u
MN2912   Z26      #1240    #1289    0      MN1      W=    5.40u L=1.0u
MP2911   Z26      #1240    #1290    1      MP1      W=    5.40u L=1.0u
MP2910   #1243    #1004    #1288    1      MP1      W=    1.80u L=1.0u
MN2909   #1250    #1169    #1273    0      MN1      W=    1.80u L=1.0u
MP2908   #1250    #1169    #1287    1      MP1      W=    1.80u L=1.0u
MP2907   #1257    #1168    #1286    1      MP1      W=    1.80u L=1.0u
MN2906   #1257    #1168    #1272    0      MN1      W=    1.80u L=1.0u
MN2905   #1249    #1167    #1271    0      MN1      W=    1.80u L=1.0u
MP2904   #1249    #1167    #1285    1      MP1      W=    1.80u L=1.0u
MP2903   #1256    #1166    #1284    1      MP1      W=    1.80u L=1.0u
MN2902   #1256    #1166    #1270    0      MN1      W=    1.80u L=1.0u
MN2901   #1248    #1165    #1269    0      MN1      W=    1.80u L=1.0u
MP2900   #1248    #1165    #1283    1      MP1      W=    1.80u L=1.0u
MP2899   #1255    #1164    #1282    1      MP1      W=    1.80u L=1.0u
MN2898   #1255    #1164    #1268    0      MN1      W=    1.80u L=1.0u
MN2897   #1247    #1163    #1267    0      MN1      W=    1.80u L=1.0u
MP2896   #1247    #1163    #1281    1      MP1      W=    1.80u L=1.0u
MP2895   #1254    #1162    #1280    1      MP1      W=    1.80u L=1.0u
MN2894   #1254    #1162    #1266    0      MN1      W=    1.80u L=1.0u
MN2893   #1246    #1161    #1265    0      MN1      W=    1.80u L=1.0u
MP2892   #1246    #1161    #1279    1      MP1      W=    1.80u L=1.0u
MP2891   #1253    #1160    #1278    1      MP1      W=    1.80u L=1.0u
MN2890   #1253    #1160    #1264    0      MN1      W=    1.80u L=1.0u
MN2889   #1245    #1159    #1263    0      MN1      W=    1.80u L=1.0u
MP2888   #1245    #1159    #1277    1      MP1      W=    1.80u L=1.0u
MP2887   #1252    #1158    #1276    1      MP1      W=    1.80u L=1.0u
MN2886   #1252    #1158    #1262    0      MN1      W=    1.80u L=1.0u
MN2885   #1244    #1157    #1261    0      MN1      W=    1.80u L=1.0u
MP2884   #1244    #1157    #1275    1      MP1      W=    1.80u L=1.0u
MP2883   #1251    #1156    #1274    1      MP1      W=    1.80u L=1.0u
MN2882   #1251    #1156    #1260    0      MN1      W=    1.80u L=1.0u
MN2881   #1243    #1004    #1259    0      MN1      W=    1.80u L=1.0u
MP2880   #1207    #1208    Z26      1      MP1      W=    1.80u L=1.0u
MP2879   #1240    #1170    1      1      MP1      W=    1.80u L=1.0u
MN2878   #1206    #1208    Z26      0      MN1      W=    1.80u L=1.0u
MN2877   #1222    #1169    #1257    0      MN1      W=    1.80u L=1.0u
MN2876   #1220    #1167    #1256    0      MN1      W=    1.80u L=1.0u
MN2875   #1218    #1165    #1255    0      MN1      W=    1.80u L=1.0u
MN2874   #1216    #1163    #1254    0      MN1      W=    1.80u L=1.0u
MN2873   #1214    #1161    #1253    0      MN1      W=    1.80u L=1.0u
MN2872   #1212    #1159    #1252    0      MN1      W=    1.80u L=1.0u
MN2871   #1210    #1157    #1251    0      MN1      W=    1.80u L=1.0u
MP2870   #1238    #1156    #1243    1      MP1      W=    1.80u L=1.0u
MP2869   #1237    #1092    #1250    1      MP1      W=    1.80u L=1.0u
MP2868   #1236    #1169    #1257    1      MP1      W=    1.80u L=1.0u
MP2867   #1235    #1168    #1249    1      MP1      W=    1.80u L=1.0u
MP2866   #1234    #1167    #1256    1      MP1      W=    1.80u L=1.0u
MP2865   #1233    #1166    #1248    1      MP1      W=    1.80u L=1.0u
MP2864   #1232    #1165    #1255    1      MP1      W=    1.80u L=1.0u
MP2863   #1231    #1164    #1247    1      MP1      W=    1.80u L=1.0u
MP2862   #1230    #1163    #1254    1      MP1      W=    1.80u L=1.0u
MP2861   #1229    #1162    #1246    1      MP1      W=    1.80u L=1.0u
MP2860   #1228    #1161    #1253    1      MP1      W=    1.80u L=1.0u
MP2859   #1227    #1160    #1245    1      MP1      W=    1.80u L=1.0u
MP2858   #1226    #1159    #1252    1      MP1      W=    1.80u L=1.0u
MP2857   #1225    #1158    #1244    1      MP1      W=    1.80u L=1.0u
MP2856   #1224    #1157    #1251    1      MP1      W=    1.80u L=1.0u
MN2855   #1223    #1092    #1250    0      MN1      W=    1.80u L=1.0u
MN2854   #1221    #1168    #1249    0      MN1      W=    1.80u L=1.0u
MN2853   #1219    #1166    #1248    0      MN1      W=    1.80u L=1.0u
MN2852   #1217    #1164    #1247    0      MN1      W=    1.80u L=1.0u
MN2851   #1215    #1162    #1246    0      MN1      W=    1.80u L=1.0u
MN2850   #1213    #1160    #1245    0      MN1      W=    1.80u L=1.0u
MN2849   #1211    #1158    #1244    0      MN1      W=    1.80u L=1.0u
MN2848   #1209    #1156    #1243    0      MN1      W=    1.80u L=1.0u
MP2847   #1239    X9       1      1      MP1      W=   10.80u L=1.0u
MN2846   #1242    X9       #1239    0      MN1      W=    3.60u L=1.0u
MN2845   #1241    #1170    #1240    0      MN1      W=    1.80u L=1.0u
MN2844   0      #1168    #1222    0      MN1      W=    1.80u L=1.0u
MN2843   0      #1166    #1220    0      MN1      W=    1.80u L=1.0u
MN2842   0      #1164    #1218    0      MN1      W=    1.80u L=1.0u
MN2841   0      #1162    #1216    0      MN1      W=    1.80u L=1.0u
MN2840   0      #1160    #1214    0      MN1      W=    1.80u L=1.0u
MN2839   0      #1158    #1212    0      MN1      W=    1.80u L=1.0u
MN2838   0      #1156    #1210    0      MN1      W=    1.80u L=1.0u
MP2837   1      #1004    #1238    1      MP1      W=    1.80u L=1.0u
MN2836   0      #1169    #1223    0      MN1      W=    1.80u L=1.0u
MP2835   1      #1169    #1237    1      MP1      W=    1.80u L=1.0u
MP2834   1      #1168    #1236    1      MP1      W=    1.80u L=1.0u
MN2833   0      #1167    #1221    0      MN1      W=    1.80u L=1.0u
MP2832   1      #1167    #1235    1      MP1      W=    1.80u L=1.0u
MP2831   1      #1166    #1234    1      MP1      W=    1.80u L=1.0u
MN2830   0      #1165    #1219    0      MN1      W=    1.80u L=1.0u
MP2829   1      #1165    #1233    1      MP1      W=    1.80u L=1.0u
MP2828   1      #1164    #1232    1      MP1      W=    1.80u L=1.0u
MN2827   0      #1163    #1217    0      MN1      W=    1.80u L=1.0u
MP2826   1      #1163    #1231    1      MP1      W=    1.80u L=1.0u
MP2825   1      #1162    #1230    1      MP1      W=    1.80u L=1.0u
MN2824   0      #1161    #1215    0      MN1      W=    1.80u L=1.0u
MP2823   1      #1161    #1229    1      MP1      W=    1.80u L=1.0u
MP2822   1      #1160    #1228    1      MP1      W=    1.80u L=1.0u
MN2821   0      #1159    #1213    0      MN1      W=    1.80u L=1.0u
MP2820   1      #1159    #1227    1      MP1      W=    1.80u L=1.0u
MP2819   1      #1158    #1226    1      MP1      W=    1.80u L=1.0u
MN2818   0      #1157    #1211    0      MN1      W=    1.80u L=1.0u
MP2817   1      #1157    #1225    1      MP1      W=    1.80u L=1.0u
MP2816   1      #1156    #1224    1      MP1      W=    1.80u L=1.0u
MN2815   0      #1004    #1209    0      MN1      W=    1.80u L=1.0u
MN2814   0      #1240    #1206    0      MN1      W=    5.40u L=1.0u
MP2813   1      #1240    #1207    1      MP1      W=    5.40u L=1.0u
MP2812   1      X10      #1239    1      MP1      W=   10.80u L=1.0u
MP2811   1      #1171    #1240    1      MP1      W=    1.80u L=1.0u
MN2810   0      X10      #1242    0      MN1      W=    3.60u L=1.0u
MN2809   0      #1171    #1241    0      MN1      W=    1.80u L=1.0u
MP2808   #1238    #1005    1      1      MP1      W=    5.40u L=1.0u
MP2807   #1237    #907     1      1      MP1      W=    5.40u L=1.0u
MP2806   #1236    #914     1      1      MP1      W=    5.40u L=1.0u
MP2805   #1235    #906     1      1      MP1      W=    5.40u L=1.0u
MP2804   #1234    #913     1      1      MP1      W=    5.40u L=1.0u
MP2803   #1233    #905     1      1      MP1      W=    5.40u L=1.0u
MP2802   #1232    #912     1      1      MP1      W=    5.40u L=1.0u
MP2801   #1231    #904     1      1      MP1      W=    5.40u L=1.0u
MP2800   #1230    #911     1      1      MP1      W=    5.40u L=1.0u
MP2799   #1229    #903     1      1      MP1      W=    5.40u L=1.0u
MP2798   #1228    #910     1      1      MP1      W=    5.40u L=1.0u
MP2797   #1227    #902     1      1      MP1      W=    5.40u L=1.0u
MP2796   #1226    #909     1      1      MP1      W=    5.40u L=1.0u
MP2795   #1225    #901     1      1      MP1      W=    5.40u L=1.0u
MP2794   #1224    #1003    1      1      MP1      W=    5.40u L=1.0u
MN2793   #1223    #907     0      0      MN1      W=    5.40u L=1.0u
MN2792   #1222    #914     0      0      MN1      W=    5.40u L=1.0u
MN2791   #1221    #906     0      0      MN1      W=    5.40u L=1.0u
MN2790   #1220    #913     0      0      MN1      W=    5.40u L=1.0u
MN2789   #1219    #905     0      0      MN1      W=    5.40u L=1.0u
MN2788   #1218    #912     0      0      MN1      W=    5.40u L=1.0u
MN2787   #1217    #904     0      0      MN1      W=    5.40u L=1.0u
MN2786   #1216    #911     0      0      MN1      W=    5.40u L=1.0u
MN2785   #1215    #903     0      0      MN1      W=    5.40u L=1.0u
MN2784   #1214    #910     0      0      MN1      W=    5.40u L=1.0u
MN2783   #1213    #902     0      0      MN1      W=    5.40u L=1.0u
MN2782   #1212    #909     0      0      MN1      W=    5.40u L=1.0u
MN2781   #1211    #901     0      0      MN1      W=    5.40u L=1.0u
MN2780   #1210    #1003    0      0      MN1      W=    5.40u L=1.0u
MN2779   #1209    #1005    0      0      MN1      W=    5.40u L=1.0u
MN2778   #1173    #1239    0      0      MN1      W=    3.60u L=1.0u
MN2777   #1208    #710     0      0      MN1      W=    1.80u L=1.0u
MP2776   #916     #1239    1      1      MP1      W=   10.80u L=1.0u
MP2775   #1207    #908     1      1      MP1      W=    5.40u L=1.0u
MP2774   #1208    #710     1      1      MP1      W=    1.80u L=1.0u
MN2773   #1206    #908     0      0      MN1      W=    5.40u L=1.0u
MP2772   1      #1137    #1238    1      MP1      W=    5.40u L=1.0u
MN2771   0      #1151    #1223    0      MN1      W=    5.40u L=1.0u
MP2770   1      #1151    #1237    1      MP1      W=    5.40u L=1.0u
MP2769   1      #1150    #1236    1      MP1      W=    5.40u L=1.0u
MN2768   0      #1150    #1222    0      MN1      W=    5.40u L=1.0u
MN2767   0      #1149    #1221    0      MN1      W=    5.40u L=1.0u
MP2766   1      #1149    #1235    1      MP1      W=    5.40u L=1.0u
MP2765   1      #1148    #1234    1      MP1      W=    5.40u L=1.0u
MN2764   0      #1148    #1220    0      MN1      W=    5.40u L=1.0u
MN2763   0      #1147    #1219    0      MN1      W=    5.40u L=1.0u
MP2762   1      #1147    #1233    1      MP1      W=    5.40u L=1.0u
MP2761   1      #1146    #1232    1      MP1      W=    5.40u L=1.0u
MN2760   0      #1146    #1218    0      MN1      W=    5.40u L=1.0u
MN2759   0      #1145    #1217    0      MN1      W=    5.40u L=1.0u
MP2758   1      #1145    #1231    1      MP1      W=    5.40u L=1.0u
MP2757   1      #1144    #1230    1      MP1      W=    5.40u L=1.0u
MN2756   0      #1144    #1216    0      MN1      W=    5.40u L=1.0u
MN2755   0      #1143    #1215    0      MN1      W=    5.40u L=1.0u
MP2754   1      #1143    #1229    1      MP1      W=    5.40u L=1.0u
MP2753   1      #1142    #1228    1      MP1      W=    5.40u L=1.0u
MN2752   0      #1142    #1214    0      MN1      W=    5.40u L=1.0u
MN2751   0      #1141    #1213    0      MN1      W=    5.40u L=1.0u
MP2750   1      #1141    #1227    1      MP1      W=    5.40u L=1.0u
MP2749   1      #1140    #1226    1      MP1      W=    5.40u L=1.0u
MN2748   0      #1140    #1212    0      MN1      W=    5.40u L=1.0u
MN2747   0      #1139    #1211    0      MN1      W=    5.40u L=1.0u
MP2746   1      #1139    #1225    1      MP1      W=    5.40u L=1.0u
MP2745   1      #1138    #1224    1      MP1      W=    5.40u L=1.0u
MN2744   0      #1138    #1210    0      MN1      W=    5.40u L=1.0u
MN2743   0      #1137    #1209    0      MN1      W=    5.40u L=1.0u
MN2742   #916     X10      #1173    0      MN1      W=    3.60u L=1.0u
MP2741   #1205    X10      #916     1      MP1      W=   10.80u L=1.0u
MP2740   1      #1134    #1207    1      MP1      W=    5.40u L=1.0u
MN2739   0      #1134    #1206    0      MN1      W=    5.40u L=1.0u
MP2738   #1189    #1137    1      1      MP1      W=    5.40u L=1.0u
MP2737   #1203    #1151    1      1      MP1      W=    5.40u L=1.0u
MP2736   #1202    #1150    1      1      MP1      W=    5.40u L=1.0u
MP2735   #1201    #1149    1      1      MP1      W=    5.40u L=1.0u
MP2734   #1200    #1148    1      1      MP1      W=    5.40u L=1.0u
MP2733   #1199    #1147    1      1      MP1      W=    5.40u L=1.0u
MP2732   #1198    #1146    1      1      MP1      W=    5.40u L=1.0u
MP2731   #1197    #1145    1      1      MP1      W=    5.40u L=1.0u
MP2730   #1196    #1144    1      1      MP1      W=    5.40u L=1.0u
MP2729   #1195    #1143    1      1      MP1      W=    5.40u L=1.0u
MP2728   #1194    #1142    1      1      MP1      W=    5.40u L=1.0u
MP2727   #1193    #1141    1      1      MP1      W=    5.40u L=1.0u
MP2726   #1192    #1140    1      1      MP1      W=    5.40u L=1.0u
MP2725   #1191    #1139    1      1      MP1      W=    5.40u L=1.0u
MP2724   #1190    #1138    1      1      MP1      W=    5.40u L=1.0u
MN2723   #1188    #1151    0      0      MN1      W=    5.40u L=1.0u
MN2722   #1187    #1150    0      0      MN1      W=    5.40u L=1.0u
MN2721   #1186    #1149    0      0      MN1      W=    5.40u L=1.0u
MN2720   #1185    #1148    0      0      MN1      W=    5.40u L=1.0u
MN2719   #1184    #1147    0      0      MN1      W=    5.40u L=1.0u
MN2718   #1183    #1146    0      0      MN1      W=    5.40u L=1.0u
MN2717   #1182    #1145    0      0      MN1      W=    5.40u L=1.0u
MN2716   #1181    #1144    0      0      MN1      W=    5.40u L=1.0u
MN2715   #1180    #1143    0      0      MN1      W=    5.40u L=1.0u
MN2714   #1179    #1142    0      0      MN1      W=    5.40u L=1.0u
MN2713   #1178    #1141    0      0      MN1      W=    5.40u L=1.0u
MN2712   #1177    #1140    0      0      MN1      W=    5.40u L=1.0u
MN2711   #1176    #1139    0      0      MN1      W=    5.40u L=1.0u
MN2710   #1175    #1138    0      0      MN1      W=    5.40u L=1.0u
MP2709   1      X9       #1205    1      MP1      W=   10.80u L=1.0u
MN2708   #1174    #1137    0      0      MN1      W=    5.40u L=1.0u
MN2707   #1173    X9       #916     0      MN1      W=    3.60u L=1.0u
MN2706   #710     #1132    0      0      MN1      W=    1.80u L=1.0u
MP2705   #1154    #1132    1      1      MP1      W=    5.40u L=1.0u
MP2704   #1171    #1094    1      1      MP1      W=    5.40u L=1.0u
MN2703   #1172    #1094    #1171    0      MN1      W=    5.40u L=1.0u
MP2702   #1092    #907     #1203    1      MP1      W=    5.40u L=1.0u
MP2701   #1169    #914     #1202    1      MP1      W=    5.40u L=1.0u
MP2700   #1168    #906     #1201    1      MP1      W=    5.40u L=1.0u
MP2699   #1167    #913     #1200    1      MP1      W=    5.40u L=1.0u
MP2698   #1166    #905     #1199    1      MP1      W=    5.40u L=1.0u
MP2697   #1165    #912     #1198    1      MP1      W=    5.40u L=1.0u
MP2696   #1164    #904     #1197    1      MP1      W=    5.40u L=1.0u
MP2695   #1163    #911     #1196    1      MP1      W=    5.40u L=1.0u
MP2694   #1162    #903     #1195    1      MP1      W=    5.40u L=1.0u
MP2693   #1161    #910     #1194    1      MP1      W=    5.40u L=1.0u
MP2692   #1160    #902     #1193    1      MP1      W=    5.40u L=1.0u
MP2691   #1159    #909     #1192    1      MP1      W=    5.40u L=1.0u
MP2690   #1158    #901     #1191    1      MP1      W=    5.40u L=1.0u
MP2689   #1157    #1003    #1190    1      MP1      W=    5.40u L=1.0u
MP2688   #1156    #1005    #1189    1      MP1      W=    5.40u L=1.0u
MN2687   #1092    #907     #1188    0      MN1      W=    5.40u L=1.0u
MN2686   #1169    #914     #1187    0      MN1      W=    5.40u L=1.0u
MN2685   #1168    #906     #1186    0      MN1      W=    5.40u L=1.0u
MN2684   #1167    #913     #1185    0      MN1      W=    5.40u L=1.0u
MN2683   #1166    #905     #1184    0      MN1      W=    5.40u L=1.0u
MN2682   #1165    #912     #1183    0      MN1      W=    5.40u L=1.0u
MN2681   #1164    #904     #1182    0      MN1      W=    5.40u L=1.0u
MN2680   #1163    #911     #1181    0      MN1      W=    5.40u L=1.0u
MN2679   #1162    #903     #1180    0      MN1      W=    5.40u L=1.0u
MN2678   #1161    #910     #1179    0      MN1      W=    5.40u L=1.0u
MN2677   #1160    #902     #1178    0      MN1      W=    5.40u L=1.0u
MN2676   #1159    #909     #1177    0      MN1      W=    5.40u L=1.0u
MN2675   #1158    #901     #1176    0      MN1      W=    5.40u L=1.0u
MN2674   #1157    #1003    #1175    0      MN1      W=    5.40u L=1.0u
MN2673   #1156    #1005    #1174    0      MN1      W=    5.40u L=1.0u
MP2672   #1136    X11      1      1      MP1      W=   10.80u L=1.0u
MN2671   0      #1152    #1172    0      MN1      W=    5.40u L=1.0u
MP2670   #710     #1170    #1154    1      MP1      W=    5.40u L=1.0u
MP2669   1      #1152    #1171    1      MP1      W=    5.40u L=1.0u
MN2668   #1155    #1170    #710     0      MN1      W=    5.40u L=1.0u
MP2667   #1126    #1169    #1092    1      MP1      W=    5.40u L=1.0u
MP2666   #1125    #1168    #1169    1      MP1      W=    5.40u L=1.0u
MP2665   #1124    #1167    #1168    1      MP1      W=    5.40u L=1.0u
MP2664   #1123    #1166    #1167    1      MP1      W=    5.40u L=1.0u
MP2663   #1122    #1165    #1166    1      MP1      W=    5.40u L=1.0u
MP2662   #1121    #1164    #1165    1      MP1      W=    5.40u L=1.0u
MP2661   #1120    #1163    #1164    1      MP1      W=    5.40u L=1.0u
MP2660   #1119    #1162    #1163    1      MP1      W=    5.40u L=1.0u
MP2659   #1118    #1161    #1162    1      MP1      W=    5.40u L=1.0u
MP2658   #1117    #1160    #1161    1      MP1      W=    5.40u L=1.0u
MP2657   #1116    #1159    #1160    1      MP1      W=    5.40u L=1.0u
MP2656   #1115    #1158    #1159    1      MP1      W=    5.40u L=1.0u
MP2655   #1114    #1157    #1158    1      MP1      W=    5.40u L=1.0u
MP2654   #1113    #1156    #1157    1      MP1      W=    5.40u L=1.0u
MP2653   #1112    #1004    #1156    1      MP1      W=    5.40u L=1.0u
MN2652   #1111    #1169    #1092    0      MN1      W=    5.40u L=1.0u
MN2651   #1110    #1168    #1169    0      MN1      W=    5.40u L=1.0u
MN2650   #1109    #1167    #1168    0      MN1      W=    5.40u L=1.0u
MN2649   #1108    #1166    #1167    0      MN1      W=    5.40u L=1.0u
MN2648   #1107    #1165    #1166    0      MN1      W=    5.40u L=1.0u
MN2647   #1106    #1164    #1165    0      MN1      W=    5.40u L=1.0u
MN2646   #1105    #1163    #1164    0      MN1      W=    5.40u L=1.0u
MN2645   #1104    #1162    #1163    0      MN1      W=    5.40u L=1.0u
MN2644   #1103    #1161    #1162    0      MN1      W=    5.40u L=1.0u
MN2643   #1102    #1160    #1161    0      MN1      W=    5.40u L=1.0u
MN2642   #1101    #1159    #1160    0      MN1      W=    5.40u L=1.0u
MN2641   #1100    #1158    #1159    0      MN1      W=    5.40u L=1.0u
MN2640   #1099    #1157    #1158    0      MN1      W=    5.40u L=1.0u
MN2639   #1098    #1156    #1157    0      MN1      W=    5.40u L=1.0u
MN2638   #1097    #1004    #1156    0      MN1      W=    5.40u L=1.0u
MP2637   1      X10      #1136    1      MP1      W=   10.80u L=1.0u
MN2636   #1153    X10      #1136    0      MN1      W=    3.60u L=1.0u
MN2635   #1152    #1134    0      0      MN1      W=    5.40u L=1.0u
MN2634   0      #1095    #1155    0      MN1      W=    5.40u L=1.0u
MP2633   #1154    #1095    #710     1      MP1      W=    1.80u L=1.0u
MP2632   #1152    #1134    1      1      MP1      W=    5.40u L=1.0u
MN2631   0      #1151    #1111    0      MN1      W=   16.20u L=1.0u
MP2630   1      #1151    #1126    1      MP1      W=   16.20u L=1.0u
MP2629   1      #1150    #1125    1      MP1      W=   16.20u L=1.0u
MN2628   0      #1150    #1110    0      MN1      W=   16.20u L=1.0u
MN2627   0      #1149    #1109    0      MN1      W=   16.20u L=1.0u
MP2626   1      #1149    #1124    1      MP1      W=   16.20u L=1.0u
MP2625   1      #1148    #1123    1      MP1      W=   16.20u L=1.0u
MN2624   0      #1148    #1108    0      MN1      W=   16.20u L=1.0u
MN2623   0      #1147    #1107    0      MN1      W=   16.20u L=1.0u
MP2622   1      #1147    #1122    1      MP1      W=   16.20u L=1.0u
MP2621   1      #1146    #1121    1      MP1      W=   16.20u L=1.0u
MN2620   0      #1146    #1106    0      MN1      W=   16.20u L=1.0u
MN2619   0      #1145    #1105    0      MN1      W=   16.20u L=1.0u
MP2618   1      #1145    #1120    1      MP1      W=   16.20u L=1.0u
MP2617   1      #1144    #1119    1      MP1      W=   16.20u L=1.0u
MN2616   0      #1144    #1104    0      MN1      W=   16.20u L=1.0u
MN2615   0      #1143    #1103    0      MN1      W=   16.20u L=1.0u
MP2614   1      #1143    #1118    1      MP1      W=   16.20u L=1.0u
MP2613   1      #1142    #1117    1      MP1      W=   16.20u L=1.0u
MN2612   0      #1142    #1102    0      MN1      W=   16.20u L=1.0u
MN2611   0      #1141    #1101    0      MN1      W=   16.20u L=1.0u
MP2610   1      #1141    #1116    1      MP1      W=   16.20u L=1.0u
MP2609   1      #1140    #1115    1      MP1      W=   16.20u L=1.0u
MN2608   0      #1140    #1100    0      MN1      W=   16.20u L=1.0u
MN2607   0      #1139    #1099    0      MN1      W=   16.20u L=1.0u
MP2606   1      #1139    #1114    1      MP1      W=   16.20u L=1.0u
MP2605   1      #1138    #1113    1      MP1      W=   16.20u L=1.0u
MN2604   0      #1138    #1098    0      MN1      W=   16.20u L=1.0u
MN2603   0      #1137    #1097    0      MN1      W=   16.20u L=1.0u
MP2602   1      #1137    #1112    1      MP1      W=   16.20u L=1.0u
MN2601   0      X11      #1153    0      MN1      W=    3.60u L=1.0u
MN2570   #1132    #1134    0      0      MN1      W=    5.40u L=1.0u
MN2569   #1134    #1092    0      0      MN1      W=    5.40u L=1.0u
MP2568   #1135    #1092    #1134    1      MP1      W=    5.40u L=1.0u
MP2552   1      #1136    #985     1      MP1      W=   10.80u L=1.0u
MP2551   #1133    #1134    #1132    1      MP1      W=    5.40u L=1.0u
MN2535   #1131    #1136    0      0      MN1      W=    3.60u L=1.0u
MP2534   1      #915     #1135    1      MP1      W=    5.40u L=1.0u
MN2533   0      #915     #1134    0      MN1      W=    5.40u L=1.0u
MP2532   1      #908     #1133    1      MP1      W=    5.40u L=1.0u
MN2531   0      #908     #1132    0      MN1      W=    5.40u L=1.0u
MN2530   #1093    #916     #1131    0      MN1      W=    3.60u L=1.0u
MP2529   #985     #916     1      1      MP1      W=   10.80u L=1.0u
MN2528   #1127    #915     0      0      MN1      W=    5.40u L=1.0u
MN2527   #1111    #907     0      0      MN1      W=   10.80u L=1.0u
MN2526   #1110    #914     0      0      MN1      W=   10.80u L=1.0u
MN2525   #1109    #906     0      0      MN1      W=   10.80u L=1.0u
MN2524   #1108    #913     0      0      MN1      W=   10.80u L=1.0u
MN2523   #1107    #905     0      0      MN1      W=   10.80u L=1.0u
MN2522   #1106    #912     0      0      MN1      W=   10.80u L=1.0u
MN2521   #1105    #904     0      0      MN1      W=   10.80u L=1.0u
MN2520   #1104    #911     0      0      MN1      W=   10.80u L=1.0u
MN2519   #1103    #903     0      0      MN1      W=   10.80u L=1.0u
MN2518   #1102    #910     0      0      MN1      W=   10.80u L=1.0u
MN2517   #1101    #902     0      0      MN1      W=   10.80u L=1.0u
MN2516   #1100    #909     0      0      MN1      W=   10.80u L=1.0u
MN2515   #1099    #901     0      0      MN1      W=   10.80u L=1.0u
MN2514   #1098    #1003    0      0      MN1      W=   10.80u L=1.0u
MN2513   #1097    #1005    0      0      MN1      W=   10.80u L=1.0u
MP2512   #1094    #915     1      1      MP1      W=    5.40u L=1.0u
MP2511   #1126    #907     1      1      MP1      W=   10.80u L=1.0u
MP2510   #1125    #914     1      1      MP1      W=   10.80u L=1.0u
MP2509   #1124    #906     1      1      MP1      W=   10.80u L=1.0u
MP2508   #1123    #913     1      1      MP1      W=   10.80u L=1.0u
MP2507   #1122    #905     1      1      MP1      W=   10.80u L=1.0u
MP2506   #1121    #912     1      1      MP1      W=   10.80u L=1.0u
MP2505   #1120    #904     1      1      MP1      W=   10.80u L=1.0u
MP2504   #1119    #911     1      1      MP1      W=   10.80u L=1.0u
MP2503   #1118    #903     1      1      MP1      W=   10.80u L=1.0u
MP2502   #1117    #910     1      1      MP1      W=   10.80u L=1.0u
MP2501   #1116    #902     1      1      MP1      W=   10.80u L=1.0u
MP2500   #1115    #909     1      1      MP1      W=   10.80u L=1.0u
MP2499   #1114    #901     1      1      MP1      W=   10.80u L=1.0u
MP2498   #1113    #1003    1      1      MP1      W=   10.80u L=1.0u
MP2497   #1112    #1005    1      1      MP1      W=   10.80u L=1.0u
MP2496   #1095    #1094    1      1      MP1      W=    5.40u L=1.0u
MN2495   #1129    #1094    0      0      MN1      W=    5.40u L=1.0u
MN2494   #985     X10      #1093    0      MN1      W=    3.60u L=1.0u
MP2493   #1128    X10      #985     1      MP1      W=   10.80u L=1.0u
MN2492   #1095    #908     #1129    0      MN1      W=    5.40u L=1.0u
MP2491   1      #908     #1095    1      MP1      W=    5.40u L=1.0u
MN2490   #1094    #1092    #1127    0      MN1      W=    5.40u L=1.0u
MP2489   1      X11      #1128    1      MP1      W=   10.80u L=1.0u
MP2488   1      #1092    #1094    1      MP1      W=    5.40u L=1.0u
MN2457   #1093    X11      #985     0      MN1      W=    3.60u L=1.0u
MN2456   0      #950     #1022    0      MN1      W=    3.60u L=1.0u
MN2455   0      #951     #1013    0      MN1      W=    3.60u L=1.0u
MN2454   0      #966     #1021    0      MN1      W=    3.60u L=1.0u
MN2453   0      #965     #1012    0      MN1      W=    3.60u L=1.0u
MN2452   0      #964     #1020    0      MN1      W=    3.60u L=1.0u
MN2451   0      #963     #1011    0      MN1      W=    3.60u L=1.0u
MN2450   0      #962     #1019    0      MN1      W=    3.60u L=1.0u
MN2449   0      #961     #1010    0      MN1      W=    3.60u L=1.0u
MN2448   0      #960     #1018    0      MN1      W=    3.60u L=1.0u
MN2447   0      #959     #1009    0      MN1      W=    3.60u L=1.0u
MN2446   0      #958     #1017    0      MN1      W=    3.60u L=1.0u
MN2445   0      #957     #1008    0      MN1      W=    3.60u L=1.0u
MN2444   0      #956     #1016    0      MN1      W=    3.60u L=1.0u
MN2443   0      #955     #1007    0      MN1      W=    3.60u L=1.0u
MN2442   0      #954     #1015    0      MN1      W=    3.60u L=1.0u
MP2441   1      #950     #1022    1      MP1      W=    3.60u L=1.0u
MP2440   1      #951     #1013    1      MP1      W=    3.60u L=1.0u
MP2439   1      #966     #1021    1      MP1      W=    3.60u L=1.0u
MP2438   1      #965     #1012    1      MP1      W=    3.60u L=1.0u
MP2437   1      #964     #1020    1      MP1      W=    3.60u L=1.0u
MP2436   1      #963     #1011    1      MP1      W=    3.60u L=1.0u
MP2435   1      #962     #1019    1      MP1      W=    3.60u L=1.0u
MP2434   1      #961     #1010    1      MP1      W=    3.60u L=1.0u
MP2433   1      #960     #1018    1      MP1      W=    3.60u L=1.0u
MP2432   1      #959     #1009    1      MP1      W=    3.60u L=1.0u
MP2431   1      #958     #1017    1      MP1      W=    3.60u L=1.0u
MP2430   1      #957     #1008    1      MP1      W=    3.60u L=1.0u
MP2429   1      #956     #1016    1      MP1      W=    3.60u L=1.0u
MP2428   1      #955     #1007    1      MP1      W=    3.60u L=1.0u
MP2427   1      #954     #1015    1      MP1      W=    3.60u L=1.0u
MP2426   1      #953     #1006    1      MP1      W=    3.60u L=1.0u
MN2425   0      #953     #1006    0      MN1      W=    3.60u L=1.0u
MP2424   1      #967     #1014    1      MP1      W=    3.60u L=1.0u
MP2423   #1057    #1005    1      1      MP1      W=   21.60u L=1.0u
MN2422   0      #967     #1014    0      MN1      W=    3.60u L=1.0u
MN2421   #1057    #1005    0      0      MN1      W=    7.20u L=1.0u
MP2418   #1091    #1022    1      1      MP1      W=    3.60u L=1.0u
MP2417   #1090    #1013    1      1      MP1      W=    3.60u L=1.0u
MP2416   #1089    #966     1      1      MP1      W=    3.60u L=1.0u
MP2415   #1088    #1012    1      1      MP1      W=    3.60u L=1.0u
MP2414   #1087    #964     1      1      MP1      W=    3.60u L=1.0u
MP2413   #1086    #1011    1      1      MP1      W=    3.60u L=1.0u
MP2412   #1085    #962     1      1      MP1      W=    3.60u L=1.0u
MP2411   #1084    #1010    1      1      MP1      W=    3.60u L=1.0u
MP2410   #1083    #960     1      1      MP1      W=    3.60u L=1.0u
MP2409   #1082    #1009    1      1      MP1      W=    3.60u L=1.0u
MP2408   #1081    #958     1      1      MP1      W=    3.60u L=1.0u
MP2407   #1080    #1008    1      1      MP1      W=    3.60u L=1.0u
MP2406   #1079    #956     1      1      MP1      W=    3.60u L=1.0u
MP2405   #1078    #1007    1      1      MP1      W=    3.60u L=1.0u
MP2404   #1077    #954     1      1      MP1      W=    3.60u L=1.0u
MP2403   #1076    #1006    1      1      MP1      W=    3.60u L=1.0u
MP2402   #1075    #967     1      1      MP1      W=    3.60u L=1.0u
MN2401   #1074    #950     0      0      MN1      W=    3.60u L=1.0u
MN2400   #1073    #951     0      0      MN1      W=    3.60u L=1.0u
MN2399   #1072    #1021    0      0      MN1      W=    3.60u L=1.0u
MN2398   #1071    #965     0      0      MN1      W=    3.60u L=1.0u
MN2397   #1070    #1020    0      0      MN1      W=    3.60u L=1.0u
MN2396   #1069    #963     0      0      MN1      W=    3.60u L=1.0u
MN2395   #1068    #1019    0      0      MN1      W=    3.60u L=1.0u
MN2394   #1067    #961     0      0      MN1      W=    3.60u L=1.0u
MN2393   #1066    #1018    0      0      MN1      W=    3.60u L=1.0u
MN2392   #1065    #959     0      0      MN1      W=    3.60u L=1.0u
MN2391   #1064    #1017    0      0      MN1      W=    3.60u L=1.0u
MN2390   #1063    #957     0      0      MN1      W=    3.60u L=1.0u
MN2389   #1062    #1016    0      0      MN1      W=    3.60u L=1.0u
MN2388   #1061    #955     0      0      MN1      W=    3.60u L=1.0u
MN2387   #1060    #1015    0      0      MN1      W=    3.60u L=1.0u
MN2386   #1059    #953     0      0      MN1      W=    3.60u L=1.0u
MN2385   #1058    #1014    0      0      MN1      W=    3.60u L=1.0u
MP2384   #1001    #1057    #1091    1      MP1      W=    3.60u L=1.0u
MP2383   #1000    #1057    #1090    1      MP1      W=    3.60u L=1.0u
MP2382   #999     #1057    #1089    1      MP1      W=    3.60u L=1.0u
MP2381   #998     #1057    #1088    1      MP1      W=    3.60u L=1.0u
MP2380   #997     #1057    #1087    1      MP1      W=    3.60u L=1.0u
MP2379   #996     #1057    #1086    1      MP1      W=    3.60u L=1.0u
MP2378   #995     #1057    #1085    1      MP1      W=    3.60u L=1.0u
MP2377   #994     #1057    #1084    1      MP1      W=    3.60u L=1.0u
MP2376   #993     #1057    #1083    1      MP1      W=    3.60u L=1.0u
MP2375   #992     #1057    #1082    1      MP1      W=    3.60u L=1.0u
MP2374   #991     #1057    #1081    1      MP1      W=    3.60u L=1.0u
MP2373   #990     #1057    #1080    1      MP1      W=    3.60u L=1.0u
MP2372   #989     #1057    #1079    1      MP1      W=    3.60u L=1.0u
MP2371   #988     #1057    #1078    1      MP1      W=    3.60u L=1.0u
MP2370   #987     #1057    #1077    1      MP1      W=    3.60u L=1.0u
MP2369   #986     #1057    #1076    1      MP1      W=    3.60u L=1.0u
MN2368   #1001    #1057    #1074    0      MN1      W=    3.60u L=1.0u
MN2367   #1000    #1057    #1073    0      MN1      W=    3.60u L=1.0u
MN2366   #999     #1057    #1072    0      MN1      W=    3.60u L=1.0u
MN2365   #998     #1057    #1071    0      MN1      W=    3.60u L=1.0u
MN2364   #997     #1057    #1070    0      MN1      W=    3.60u L=1.0u
MN2363   #996     #1057    #1069    0      MN1      W=    3.60u L=1.0u
MN2362   #995     #1057    #1068    0      MN1      W=    3.60u L=1.0u
MN2361   #994     #1057    #1067    0      MN1      W=    3.60u L=1.0u
MN2360   #993     #1057    #1066    0      MN1      W=    3.60u L=1.0u
MN2359   #992     #1057    #1065    0      MN1      W=    3.60u L=1.0u
MN2358   #991     #1057    #1064    0      MN1      W=    3.60u L=1.0u
MN2357   #990     #1057    #1063    0      MN1      W=    3.60u L=1.0u
MN2356   #989     #1057    #1062    0      MN1      W=    3.60u L=1.0u
MN2355   #988     #1057    #1061    0      MN1      W=    3.60u L=1.0u
MN2354   #987     #1057    #1060    0      MN1      W=    3.60u L=1.0u
MN2353   #986     #1057    #1059    0      MN1      W=    3.60u L=1.0u
MP2352   #1002    #1057    #1075    1      MP1      W=    3.60u L=1.0u
MN2351   #1002    #1057    #1058    0      MN1      W=    3.60u L=1.0u
MP2350   #1005    X11      1      1      MP1      W=   21.60u L=1.0u
MN2349   #1005    X11      0      0      MN1      W=    7.20u L=1.0u
MN2348   #1039    #1005    #1001    0      MN1      W=    3.60u L=1.0u
MP2347   #1056    #1005    #1001    1      MP1      W=    3.60u L=1.0u
MP2346   #1054    #1005    #1000    1      MP1      W=    3.60u L=1.0u
MN2345   #1037    #1005    #999     0      MN1      W=    3.60u L=1.0u
MP2344   #1053    #1005    #999     1      MP1      W=    3.60u L=1.0u
MP2343   #1052    #1005    #998     1      MP1      W=    3.60u L=1.0u
MN2342   #1035    #1005    #997     0      MN1      W=    3.60u L=1.0u
MP2341   #1051    #1005    #997     1      MP1      W=    3.60u L=1.0u
MP2340   #1050    #1005    #996     1      MP1      W=    3.60u L=1.0u
MN2339   #1033    #1005    #995     0      MN1      W=    3.60u L=1.0u
MP2338   #1049    #1005    #995     1      MP1      W=    3.60u L=1.0u
MP2337   #1048    #1005    #994     1      MP1      W=    3.60u L=1.0u
MN2336   #1031    #1005    #993     0      MN1      W=    3.60u L=1.0u
MP2335   #1047    #1005    #993     1      MP1      W=    3.60u L=1.0u
MP2334   #1046    #1005    #992     1      MP1      W=    3.60u L=1.0u
MN2333   #1029    #1005    #991     0      MN1      W=    3.60u L=1.0u
MP2332   #1045    #1005    #991     1      MP1      W=    3.60u L=1.0u
MP2331   #1044    #1005    #990     1      MP1      W=    3.60u L=1.0u
MN2330   #1027    #1005    #989     0      MN1      W=    3.60u L=1.0u
MP2329   #1043    #1005    #989     1      MP1      W=    3.60u L=1.0u
MP2328   #1042    #1005    #988     1      MP1      W=    3.60u L=1.0u
MN2327   #1025    #1005    #987     0      MN1      W=    3.60u L=1.0u
MP2326   #1041    #1005    #987     1      MP1      W=    3.60u L=1.0u
MP2325   #1040    #1005    #986     1      MP1      W=    3.60u L=1.0u
MN2324   #1024    #1005    #986     0      MN1      W=    3.60u L=1.0u
MN2323   #1038    #1005    #1000    0      MN1      W=    3.60u L=1.0u
MN2322   #1036    #1005    #998     0      MN1      W=    3.60u L=1.0u
MN2321   #1034    #1005    #996     0      MN1      W=    3.60u L=1.0u
MN2320   #1032    #1005    #994     0      MN1      W=    3.60u L=1.0u
MN2319   #1030    #1005    #992     0      MN1      W=    3.60u L=1.0u
MN2318   #1028    #1005    #990     0      MN1      W=    3.60u L=1.0u
MN2317   #1026    #1005    #988     0      MN1      W=    3.60u L=1.0u
MN2316   #1023    #1005    #1002    0      MN1      W=    3.60u L=1.0u
MP2315   #1055    #1005    #1002    1      MP1      W=    3.60u L=1.0u
MP2312   1      #950     #1056    1      MP1      W=    3.60u L=1.0u
MP2311   1      #1014    #1055    1      MP1      W=    3.60u L=1.0u
MN2310   0      #1022    #1039    0      MN1      W=    3.60u L=1.0u
MP2309   1      #951     #1054    1      MP1      W=    3.60u L=1.0u
MN2308   0      #1013    #1038    0      MN1      W=    3.60u L=1.0u
MN2307   0      #966     #1037    0      MN1      W=    3.60u L=1.0u
MP2306   1      #1021    #1053    1      MP1      W=    3.60u L=1.0u
MP2305   1      #965     #1052    1      MP1      W=    3.60u L=1.0u
MN2304   0      #1012    #1036    0      MN1      W=    3.60u L=1.0u
MN2303   0      #964     #1035    0      MN1      W=    3.60u L=1.0u
MP2302   1      #1020    #1051    1      MP1      W=    3.60u L=1.0u
MP2301   1      #963     #1050    1      MP1      W=    3.60u L=1.0u
MN2300   0      #1011    #1034    0      MN1      W=    3.60u L=1.0u
MN2299   0      #962     #1033    0      MN1      W=    3.60u L=1.0u
MP2298   1      #1019    #1049    1      MP1      W=    3.60u L=1.0u
MP2297   1      #961     #1048    1      MP1      W=    3.60u L=1.0u
MN2296   0      #1010    #1032    0      MN1      W=    3.60u L=1.0u
MN2295   0      #960     #1031    0      MN1      W=    3.60u L=1.0u
MP2294   1      #1018    #1047    1      MP1      W=    3.60u L=1.0u
MP2293   1      #959     #1046    1      MP1      W=    3.60u L=1.0u
MN2292   0      #1009    #1030    0      MN1      W=    3.60u L=1.0u
MN2291   0      #958     #1029    0      MN1      W=    3.60u L=1.0u
MP2290   1      #1017    #1045    1      MP1      W=    3.60u L=1.0u
MP2289   1      #957     #1044    1      MP1      W=    3.60u L=1.0u
MN2288   0      #1008    #1028    0      MN1      W=    3.60u L=1.0u
MN2287   0      #956     #1027    0      MN1      W=    3.60u L=1.0u
MP2286   1      #1016    #1043    1      MP1      W=    3.60u L=1.0u
MP2285   1      #955     #1042    1      MP1      W=    3.60u L=1.0u
MN2284   0      #1007    #1026    0      MN1      W=    3.60u L=1.0u
MN2283   0      #954     #1025    0      MN1      W=    3.60u L=1.0u
MP2282   1      #1015    #1041    1      MP1      W=    3.60u L=1.0u
MP2281   1      #953     #1040    1      MP1      W=    3.60u L=1.0u
MN2280   0      #1006    #1024    0      MN1      W=    3.60u L=1.0u
MN2279   0      #967     #1023    0      MN1      W=    3.60u L=1.0u
MN2278   #952     #985     0      0      MN1      W=   14.40u L=1.0u
MP2277   #952     #985     1      1      MP1      W=   43.20u L=1.0u
MP2276   #1004    #1002    1      1      MP1      W=   10.80u L=1.0u
MN2275   #726     #1001    0      0      MN1      W=   10.80u L=1.0u
MN2274   #725     #1000    0      0      MN1      W=   10.80u L=1.0u
MN2273   #724     #999     0      0      MN1      W=   10.80u L=1.0u
MN2272   #723     #998     0      0      MN1      W=   10.80u L=1.0u
MN2271   #722     #997     0      0      MN1      W=   10.80u L=1.0u
MN2270   #721     #996     0      0      MN1      W=   10.80u L=1.0u
MN2269   #720     #995     0      0      MN1      W=   10.80u L=1.0u
MN2268   #719     #994     0      0      MN1      W=   10.80u L=1.0u
MN2267   #718     #993     0      0      MN1      W=   10.80u L=1.0u
MN2266   #717     #992     0      0      MN1      W=   10.80u L=1.0u
MN2265   #716     #991     0      0      MN1      W=   10.80u L=1.0u
MN2264   #715     #990     0      0      MN1      W=   10.80u L=1.0u
MN2263   #714     #989     0      0      MN1      W=   10.80u L=1.0u
MN2262   #713     #988     0      0      MN1      W=   10.80u L=1.0u
MN2261   #712     #987     0      0      MN1      W=   10.80u L=1.0u
MN2260   #1003    #986     0      0      MN1      W=   10.80u L=1.0u
MN2259   #1004    #1002    0      0      MN1      W=   10.80u L=1.0u
MP2258   #726     #1001    1      1      MP1      W=   10.80u L=1.0u
MP2257   #725     #1000    1      1      MP1      W=   10.80u L=1.0u
MP2256   #724     #999     1      1      MP1      W=   10.80u L=1.0u
MP2255   #723     #998     1      1      MP1      W=   10.80u L=1.0u
MP2254   #722     #997     1      1      MP1      W=   10.80u L=1.0u
MP2253   #721     #996     1      1      MP1      W=   10.80u L=1.0u
MP2252   #720     #995     1      1      MP1      W=   10.80u L=1.0u
MP2251   #719     #994     1      1      MP1      W=   10.80u L=1.0u
MP2250   #718     #993     1      1      MP1      W=   10.80u L=1.0u
MP2249   #717     #992     1      1      MP1      W=   10.80u L=1.0u
MP2248   #716     #991     1      1      MP1      W=   10.80u L=1.0u
MP2247   #715     #990     1      1      MP1      W=   10.80u L=1.0u
MP2246   #714     #989     1      1      MP1      W=   10.80u L=1.0u
MP2245   #713     #988     1      1      MP1      W=   10.80u L=1.0u
MP2244   #712     #987     1      1      MP1      W=   10.80u L=1.0u
MP2243   #1003    #986     1      1      MP1      W=   10.80u L=1.0u
MP2204   #934     #952     1      1      MP1      W=    3.60u L=1.0u
MP2203   #933     #952     1      1      MP1      W=    3.60u L=1.0u
MP2202   #932     #952     1      1      MP1      W=    3.60u L=1.0u
MP2201   #931     #952     1      1      MP1      W=    3.60u L=1.0u
MP2200   #930     #952     1      1      MP1      W=    3.60u L=1.0u
MP2199   #929     #952     1      1      MP1      W=    3.60u L=1.0u
MP2198   #928     #952     1      1      MP1      W=    3.60u L=1.0u
MP2197   #927     #952     1      1      MP1      W=    3.60u L=1.0u
MP2196   #926     #952     1      1      MP1      W=    3.60u L=1.0u
MP2195   #925     #952     1      1      MP1      W=    3.60u L=1.0u
MP2194   #924     #952     1      1      MP1      W=    3.60u L=1.0u
MP2193   #923     #952     1      1      MP1      W=    3.60u L=1.0u
MP2192   #922     #952     1      1      MP1      W=    3.60u L=1.0u
MP2191   #921     #952     1      1      MP1      W=    3.60u L=1.0u
MP2190   #967     #917     1      1      MP1      W=    3.60u L=1.0u
MN2189   #984     #917     0      0      MN1      W=    3.60u L=1.0u
MN2188   #983     #917     0      0      MN1      W=    3.60u L=1.0u
MN2187   #982     #917     0      0      MN1      W=    3.60u L=1.0u
MN2186   #981     #917     0      0      MN1      W=    3.60u L=1.0u
MN2185   #980     #917     0      0      MN1      W=    3.60u L=1.0u
MN2184   #979     #917     0      0      MN1      W=    3.60u L=1.0u
MN2183   #978     #917     0      0      MN1      W=    3.60u L=1.0u
MN2182   #977     #917     0      0      MN1      W=    3.60u L=1.0u
MN2181   #976     #917     0      0      MN1      W=    3.60u L=1.0u
MN2180   #975     #917     0      0      MN1      W=    3.60u L=1.0u
MN2179   #974     #917     0      0      MN1      W=    3.60u L=1.0u
MN2178   #973     #917     0      0      MN1      W=    3.60u L=1.0u
MN2177   #972     #917     0      0      MN1      W=    3.60u L=1.0u
MN2176   #971     #917     0      0      MN1      W=    3.60u L=1.0u
MN2175   #970     #917     0      0      MN1      W=    3.60u L=1.0u
MN2174   #969     #917     0      0      MN1      W=    3.60u L=1.0u
MP2173   #920     #952     1      1      MP1      W=    3.60u L=1.0u
MP2171   #918     #952     1      1      MP1      W=    3.60u L=1.0u
MN2169   #968     #917     0      0      MN1      W=    3.60u L=1.0u
MP2168   #966     #51      #934     1      MP1      W=    3.60u L=1.0u
MP2167   #965     #50      #933     1      MP1      W=    3.60u L=1.0u
MP2166   #964     #49      #932     1      MP1      W=    3.60u L=1.0u
MP2165   #963     #48      #931     1      MP1      W=    3.60u L=1.0u
MP2164   #962     #47      #930     1      MP1      W=    3.60u L=1.0u
MP2163   #961     #46      #929     1      MP1      W=    3.60u L=1.0u
MP2162   #960     #45      #928     1      MP1      W=    3.60u L=1.0u
MP2161   #959     #44      #927     1      MP1      W=    3.60u L=1.0u
MP2160   #958     #43      #926     1      MP1      W=    3.60u L=1.0u
MP2159   #957     #42      #925     1      MP1      W=    3.60u L=1.0u
MP2158   #956     #41      #924     1      MP1      W=    3.60u L=1.0u
MP2157   #955     #40      #923     1      MP1      W=    3.60u L=1.0u
MP2156   #954     #39      #922     1      MP1      W=    3.60u L=1.0u
MP2155   #953     #38      #921     1      MP1      W=    3.60u L=1.0u
MN2154   #951     #52      #984     0      MN1      W=    3.60u L=1.0u
MN2153   #966     #51      #983     0      MN1      W=    3.60u L=1.0u
MN2152   #965     #50      #982     0      MN1      W=    3.60u L=1.0u
MN2151   #964     #49      #981     0      MN1      W=    3.60u L=1.0u
MN2150   #963     #48      #980     0      MN1      W=    3.60u L=1.0u
MN2149   #962     #47      #979     0      MN1      W=    3.60u L=1.0u
MN2148   #961     #46      #978     0      MN1      W=    3.60u L=1.0u
MN2147   #960     #45      #977     0      MN1      W=    3.60u L=1.0u
MN2146   #959     #44      #976     0      MN1      W=    3.60u L=1.0u
MN2145   #958     #43      #975     0      MN1      W=    3.60u L=1.0u
MN2144   #957     #42      #974     0      MN1      W=    3.60u L=1.0u
MN2143   #956     #41      #973     0      MN1      W=    3.60u L=1.0u
MN2142   #955     #40      #972     0      MN1      W=    3.60u L=1.0u
MN2141   #954     #39      #971     0      MN1      W=    3.60u L=1.0u
MN2140   #953     #38      #970     0      MN1      W=    3.60u L=1.0u
MN2139   #967     #37      #969     0      MN1      W=    3.60u L=1.0u
MP2138   1      #37      #967     1      MP1      W=    3.60u L=1.0u
MP2137   #951     #52      #920     1      MP1      W=    3.60u L=1.0u
MP2136   #950     #52      #918     1      MP1      W=    3.60u L=1.0u
MN2135   #917     #916     0      0      MN1      W=   14.40u L=1.0u
MN2134   #950     #52      #968     0      MN1      W=    3.60u L=1.0u
MP2133   #917     #916     1      1      MP1      W=   43.20u L=1.0u
MN2132   #949     #952     #951     0      MN1      W=    3.60u L=1.0u
MN2131   #948     #952     #966     0      MN1      W=    3.60u L=1.0u
MN2130   #947     #952     #965     0      MN1      W=    3.60u L=1.0u
MN2129   #946     #952     #964     0      MN1      W=    3.60u L=1.0u
MN2128   #945     #952     #963     0      MN1      W=    3.60u L=1.0u
MN2127   #944     #952     #962     0      MN1      W=    3.60u L=1.0u
MN2126   #943     #952     #961     0      MN1      W=    3.60u L=1.0u
MN2125   #942     #952     #960     0      MN1      W=    3.60u L=1.0u
MN2124   #941     #952     #959     0      MN1      W=    3.60u L=1.0u
MN2123   #940     #952     #958     0      MN1      W=    3.60u L=1.0u
MN2122   #939     #952     #957     0      MN1      W=    3.60u L=1.0u
MN2121   #938     #952     #956     0      MN1      W=    3.60u L=1.0u
MN2120   #937     #952     #955     0      MN1      W=    3.60u L=1.0u
MN2119   #936     #952     #954     0      MN1      W=    3.60u L=1.0u
MP2118   #934     #917     #966     1      MP1      W=    3.60u L=1.0u
MP2117   #933     #917     #965     1      MP1      W=    3.60u L=1.0u
MP2116   #932     #917     #964     1      MP1      W=    3.60u L=1.0u
MP2115   #931     #917     #963     1      MP1      W=    3.60u L=1.0u
MP2114   #930     #917     #962     1      MP1      W=    3.60u L=1.0u
MP2113   #929     #917     #961     1      MP1      W=    3.60u L=1.0u
MP2112   #928     #917     #960     1      MP1      W=    3.60u L=1.0u
MP2111   #927     #917     #959     1      MP1      W=    3.60u L=1.0u
MP2110   #926     #917     #958     1      MP1      W=    3.60u L=1.0u
MP2109   #925     #917     #957     1      MP1      W=    3.60u L=1.0u
MP2108   #924     #917     #956     1      MP1      W=    3.60u L=1.0u
MP2107   #923     #917     #955     1      MP1      W=    3.60u L=1.0u
MP2106   #922     #917     #954     1      MP1      W=    3.60u L=1.0u
MP2105   #921     #917     #953     1      MP1      W=    3.60u L=1.0u
MN2104   #935     #952     #953     0      MN1      W=    3.60u L=1.0u
MN2103   #919     #952     #950     0      MN1      W=    3.60u L=1.0u
MP2101   #920     #917     #951     1      MP1      W=    3.60u L=1.0u
MP2099   #918     #917     #950     1      MP1      W=    3.60u L=1.0u
MN2098   0      #51      #949     0      MN1      W=    3.60u L=1.0u
MN2097   0      #50      #948     0      MN1      W=    3.60u L=1.0u
MN2096   0      #49      #947     0      MN1      W=    3.60u L=1.0u
MN2095   0      #48      #946     0      MN1      W=    3.60u L=1.0u
MN2094   0      #47      #945     0      MN1      W=    3.60u L=1.0u
MN2093   0      #46      #944     0      MN1      W=    3.60u L=1.0u
MN2092   0      #45      #943     0      MN1      W=    3.60u L=1.0u
MN2091   0      #44      #942     0      MN1      W=    3.60u L=1.0u
MN2090   0      #43      #941     0      MN1      W=    3.60u L=1.0u
MN2089   0      #42      #940     0      MN1      W=    3.60u L=1.0u
MN2088   0      #41      #939     0      MN1      W=    3.60u L=1.0u
MN2087   0      #40      #938     0      MN1      W=    3.60u L=1.0u
MN2086   0      #39      #937     0      MN1      W=    3.60u L=1.0u
MN2085   0      #38      #936     0      MN1      W=    3.60u L=1.0u
MN2084   0      #37      #935     0      MN1      W=    3.60u L=1.0u
MP2083   1      #50      #934     1      MP1      W=    3.60u L=1.0u
MP2082   1      #49      #933     1      MP1      W=    3.60u L=1.0u
MP2081   1      #48      #932     1      MP1      W=    3.60u L=1.0u
MP2080   1      #47      #931     1      MP1      W=    3.60u L=1.0u
MP2079   1      #46      #930     1      MP1      W=    3.60u L=1.0u
MP2078   1      #45      #929     1      MP1      W=    3.60u L=1.0u
MP2077   1      #44      #928     1      MP1      W=    3.60u L=1.0u
MP2076   1      #43      #927     1      MP1      W=    3.60u L=1.0u
MP2075   1      #42      #926     1      MP1      W=    3.60u L=1.0u
MP2074   1      #41      #925     1      MP1      W=    3.60u L=1.0u
MP2073   1      #40      #924     1      MP1      W=    3.60u L=1.0u
MP2072   1      #39      #923     1      MP1      W=    3.60u L=1.0u
MP2071   1      #38      #922     1      MP1      W=    3.60u L=1.0u
MP2070   1      #37      #921     1      MP1      W=    3.60u L=1.0u
MN2069   0      #52      #919     0      MN1      W=    3.60u L=1.0u
MP2068   1      #51      #920     1      MP1      W=    3.60u L=1.0u
MP2067   1      #52      #918     1      MP1      W=    3.60u L=1.0u
MN2064   #901     #818     0      0      MN1      W=   10.80u L=1.0u
MP2063   #901     #818     1      1      MP1      W=   10.80u L=1.0u
MN2062   #908     #825     0      0      MN1      W=   10.80u L=1.0u
MN2061   #915     #832     0      0      MN1      W=   10.80u L=1.0u
MN2060   #907     #824     0      0      MN1      W=   10.80u L=1.0u
MN2059   #914     #831     0      0      MN1      W=   10.80u L=1.0u
MN2058   #906     #823     0      0      MN1      W=   10.80u L=1.0u
MN2057   #913     #830     0      0      MN1      W=   10.80u L=1.0u
MN2056   #905     #822     0      0      MN1      W=   10.80u L=1.0u
MN2055   #912     #829     0      0      MN1      W=   10.80u L=1.0u
MN2054   #904     #821     0      0      MN1      W=   10.80u L=1.0u
MN2053   #911     #828     0      0      MN1      W=   10.80u L=1.0u
MN2052   #903     #820     0      0      MN1      W=   10.80u L=1.0u
MN2051   #910     #827     0      0      MN1      W=   10.80u L=1.0u
MN2050   #902     #819     0      0      MN1      W=   10.80u L=1.0u
MN2049   #909     #826     0      0      MN1      W=   10.80u L=1.0u
MP2048   #908     #825     1      1      MP1      W=   10.80u L=1.0u
MP2047   #915     #832     1      1      MP1      W=   10.80u L=1.0u
MP2046   #907     #824     1      1      MP1      W=   10.80u L=1.0u
MP2045   #914     #831     1      1      MP1      W=   10.80u L=1.0u
MP2044   #906     #823     1      1      MP1      W=   10.80u L=1.0u
MP2043   #913     #830     1      1      MP1      W=   10.80u L=1.0u
MP2042   #905     #822     1      1      MP1      W=   10.80u L=1.0u
MP2041   #912     #829     1      1      MP1      W=   10.80u L=1.0u
MP2040   #904     #821     1      1      MP1      W=   10.80u L=1.0u
MP2039   #911     #828     1      1      MP1      W=   10.80u L=1.0u
MP2038   #903     #820     1      1      MP1      W=   10.80u L=1.0u
MP2037   #910     #827     1      1      MP1      W=   10.80u L=1.0u
MP2036   #902     #819     1      1      MP1      W=   10.80u L=1.0u
MP2035   #909     #826     1      1      MP1      W=   10.80u L=1.0u
MN2009   0      #781     #881     0      MN1      W=    1.80u L=1.0u
MN2001   Z27      #833     0      0      MN1      W=    3.60u L=1.0u
MP2000   Z27      #833     1      1      MP1      W=    3.60u L=1.0u
MP1999   #900     #747     1      1      MP1      W=    1.80u L=1.0u
MN1998   #866     #712     0      0      MN1      W=    5.40u L=1.0u
MP1997   #896     #712     1      1      MP1      W=    5.40u L=1.0u
MN1996   #881     #747     0      0      MN1      W=    1.80u L=1.0u
MP1995   #898     #485     1      1      MP1      W=    5.40u L=1.0u
MN1994   #880     #726     0      0      MN1      W=    5.40u L=1.0u
MN1993   #878     #724     0      0      MN1      W=    5.40u L=1.0u
MN1992   #876     #722     0      0      MN1      W=    5.40u L=1.0u
MN1991   #874     #720     0      0      MN1      W=    5.40u L=1.0u
MN1990   #872     #718     0      0      MN1      W=    5.40u L=1.0u
MN1989   #870     #716     0      0      MN1      W=    5.40u L=1.0u
MN1988   #868     #714     0      0      MN1      W=    5.40u L=1.0u
MP1987   #895     #726     1      1      MP1      W=    5.40u L=1.0u
MP1986   #893     #724     1      1      MP1      W=    5.40u L=1.0u
MP1985   #891     #722     1      1      MP1      W=    5.40u L=1.0u
MP1984   #889     #720     1      1      MP1      W=    5.40u L=1.0u
MP1983   #887     #718     1      1      MP1      W=    5.40u L=1.0u
MP1982   #885     #716     1      1      MP1      W=    5.40u L=1.0u
MP1981   #883     #714     1      1      MP1      W=    5.40u L=1.0u
MN1980   #897     #485     0      0      MN1      W=    5.40u L=1.0u
MP1979   #894     #725     1      1      MP1      W=    5.40u L=1.0u
MP1978   #892     #723     1      1      MP1      W=    5.40u L=1.0u
MP1977   #890     #721     1      1      MP1      W=    5.40u L=1.0u
MP1976   #888     #719     1      1      MP1      W=    5.40u L=1.0u
MP1975   #886     #717     1      1      MP1      W=    5.40u L=1.0u
MP1974   #884     #715     1      1      MP1      W=    5.40u L=1.0u
MP1973   #882     #713     1      1      MP1      W=    5.40u L=1.0u
MN1972   #879     #725     0      0      MN1      W=    5.40u L=1.0u
MN1971   #877     #723     0      0      MN1      W=    5.40u L=1.0u
MN1970   #875     #721     0      0      MN1      W=    5.40u L=1.0u
MN1969   #873     #719     0      0      MN1      W=    5.40u L=1.0u
MN1968   #871     #717     0      0      MN1      W=    5.40u L=1.0u
MN1967   #869     #715     0      0      MN1      W=    5.40u L=1.0u
MN1966   #867     #713     0      0      MN1      W=    5.40u L=1.0u
MP1965   #833     #781     #900     1      MP1      W=    1.80u L=1.0u
MP1964   #865     #727     #898     1      MP1      W=    5.40u L=1.0u
MN1963   #864     #727     #897     0      MN1      W=    5.40u L=1.0u
MP1962   #863     #582     #896     1      MP1      W=    5.40u L=1.0u
MP1961   #862     #484     #895     1      MP1      W=    5.40u L=1.0u
MP1960   #861     #491     #894     1      MP1      W=    5.40u L=1.0u
MP1959   #860     #483     #893     1      MP1      W=    5.40u L=1.0u
MP1958   #859     #490     #892     1      MP1      W=    5.40u L=1.0u
MP1957   #858     #482     #891     1      MP1      W=    5.40u L=1.0u
MP1956   #857     #489     #890     1      MP1      W=    5.40u L=1.0u
MP1955   #856     #481     #889     1      MP1      W=    5.40u L=1.0u
MP1954   #855     #488     #888     1      MP1      W=    5.40u L=1.0u
MP1953   #854     #480     #887     1      MP1      W=    5.40u L=1.0u
MP1952   #853     #487     #886     1      MP1      W=    5.40u L=1.0u
MP1951   #852     #479     #885     1      MP1      W=    5.40u L=1.0u
MP1950   #851     #486     #884     1      MP1      W=    5.40u L=1.0u
MP1949   #850     #478     #883     1      MP1      W=    5.40u L=1.0u
MP1948   #849     #580     #882     1      MP1      W=    5.40u L=1.0u
MN1947   #833     #817     #881     0      MN1      W=    1.80u L=1.0u
MN1946   #848     #484     #880     0      MN1      W=    5.40u L=1.0u
MN1945   #847     #491     #879     0      MN1      W=    5.40u L=1.0u
MN1944   #846     #483     #878     0      MN1      W=    5.40u L=1.0u
MN1943   #845     #490     #877     0      MN1      W=    5.40u L=1.0u
MN1942   #844     #482     #876     0      MN1      W=    5.40u L=1.0u
MN1941   #843     #489     #875     0      MN1      W=    5.40u L=1.0u
MN1940   #842     #481     #874     0      MN1      W=    5.40u L=1.0u
MN1939   #841     #488     #873     0      MN1      W=    5.40u L=1.0u
MN1938   #840     #480     #872     0      MN1      W=    5.40u L=1.0u
MN1937   #839     #487     #871     0      MN1      W=    5.40u L=1.0u
MN1936   #838     #479     #870     0      MN1      W=    5.40u L=1.0u
MN1935   #837     #486     #869     0      MN1      W=    5.40u L=1.0u
MN1934   #836     #478     #868     0      MN1      W=    5.40u L=1.0u
MN1933   #835     #580     #867     0      MN1      W=    5.40u L=1.0u
MN1932   #834     #582     #866     0      MN1      W=    5.40u L=1.0u
MP1931   Z28      #817     #865     1      MP1      W=    5.40u L=1.0u
MN1930   Z28      #817     #864     0      MN1      W=    5.40u L=1.0u
MP1929   #818     #581     #863     1      MP1      W=    1.80u L=1.0u
MN1928   #825     #745     #848     0      MN1      W=    1.80u L=1.0u
MP1927   #825     #745     #862     1      MP1      W=    1.80u L=1.0u
MP1926   #832     #744     #861     1      MP1      W=    1.80u L=1.0u
MN1925   #832     #744     #847     0      MN1      W=    1.80u L=1.0u
MN1924   #824     #743     #846     0      MN1      W=    1.80u L=1.0u
MP1923   #824     #743     #860     1      MP1      W=    1.80u L=1.0u
MP1922   #831     #742     #859     1      MP1      W=    1.80u L=1.0u
MN1921   #831     #742     #845     0      MN1      W=    1.80u L=1.0u
MN1920   #823     #741     #844     0      MN1      W=    1.80u L=1.0u
MP1919   #823     #741     #858     1      MP1      W=    1.80u L=1.0u
MP1918   #830     #740     #857     1      MP1      W=    1.80u L=1.0u
MN1917   #830     #740     #843     0      MN1      W=    1.80u L=1.0u
MN1916   #822     #739     #842     0      MN1      W=    1.80u L=1.0u
MP1915   #822     #739     #856     1      MP1      W=    1.80u L=1.0u
MP1914   #829     #738     #855     1      MP1      W=    1.80u L=1.0u
MN1913   #829     #738     #841     0      MN1      W=    1.80u L=1.0u
MN1912   #821     #737     #840     0      MN1      W=    1.80u L=1.0u
MP1911   #821     #737     #854     1      MP1      W=    1.80u L=1.0u
MP1910   #828     #736     #853     1      MP1      W=    1.80u L=1.0u
MN1909   #828     #736     #839     0      MN1      W=    1.80u L=1.0u
MN1908   #820     #735     #838     0      MN1      W=    1.80u L=1.0u
MP1907   #820     #735     #852     1      MP1      W=    1.80u L=1.0u
MP1906   #827     #734     #851     1      MP1      W=    1.80u L=1.0u
MN1905   #827     #734     #837     0      MN1      W=    1.80u L=1.0u
MN1904   #819     #733     #836     0      MN1      W=    1.80u L=1.0u
MP1903   #819     #733     #850     1      MP1      W=    1.80u L=1.0u
MP1902   #826     #732     #849     1      MP1      W=    1.80u L=1.0u
MN1901   #826     #732     #835     0      MN1      W=    1.80u L=1.0u
MP1900   1      #817     #833     1      MP1      W=    1.80u L=1.0u
MN1899   #818     #581     #834     0      MN1      W=    1.80u L=1.0u
MP1898   #813     #322     Z28      1      MP1      W=    1.80u L=1.0u
MN1897   #812     #322     Z28      0      MN1      W=    1.80u L=1.0u
MN1896   #795     #745     #832     0      MN1      W=    1.80u L=1.0u
MN1895   #793     #743     #831     0      MN1      W=    1.80u L=1.0u
MN1894   #791     #741     #830     0      MN1      W=    1.80u L=1.0u
MN1893   #789     #739     #829     0      MN1      W=    1.80u L=1.0u
MN1892   #787     #737     #828     0      MN1      W=    1.80u L=1.0u
MN1891   #785     #735     #827     0      MN1      W=    1.80u L=1.0u
MN1890   #783     #733     #826     0      MN1      W=    1.80u L=1.0u
MP1889   #811     #732     #818     1      MP1      W=    1.80u L=1.0u
MP1888   #810     #669     #825     1      MP1      W=    1.80u L=1.0u
MP1887   #809     #745     #832     1      MP1      W=    1.80u L=1.0u
MP1886   #808     #744     #824     1      MP1      W=    1.80u L=1.0u
MP1885   #807     #743     #831     1      MP1      W=    1.80u L=1.0u
MP1884   #806     #742     #823     1      MP1      W=    1.80u L=1.0u
MP1883   #805     #741     #830     1      MP1      W=    1.80u L=1.0u
MP1882   #804     #740     #822     1      MP1      W=    1.80u L=1.0u
MP1881   #803     #739     #829     1      MP1      W=    1.80u L=1.0u
MP1880   #802     #738     #821     1      MP1      W=    1.80u L=1.0u
MP1879   #801     #737     #828     1      MP1      W=    1.80u L=1.0u
MP1878   #800     #736     #820     1      MP1      W=    1.80u L=1.0u
MP1877   #799     #735     #827     1      MP1      W=    1.80u L=1.0u
MP1876   #798     #734     #819     1      MP1      W=    1.80u L=1.0u
MP1875   #797     #733     #826     1      MP1      W=    1.80u L=1.0u
MN1874   #796     #669     #825     0      MN1      W=    1.80u L=1.0u
MN1873   #794     #744     #824     0      MN1      W=    1.80u L=1.0u
MN1872   #792     #742     #823     0      MN1      W=    1.80u L=1.0u
MN1871   #790     #740     #822     0      MN1      W=    1.80u L=1.0u
MN1870   #788     #738     #821     0      MN1      W=    1.80u L=1.0u
MN1869   #786     #736     #820     0      MN1      W=    1.80u L=1.0u
MN1868   #784     #734     #819     0      MN1      W=    1.80u L=1.0u
MN1867   #782     #732     #818     0      MN1      W=    1.80u L=1.0u
MP1866   #817     #781     1      1      MP1      W=    1.80u L=1.0u
MP1865   #814     X11      1      1      MP1      W=   10.80u L=1.0u
MN1864   #815     X11      #814     0      MN1      W=    3.60u L=1.0u
MN1863   #816     #781     #817     0      MN1      W=    1.80u L=1.0u
MP1862   1      #817     #813     1      MP1      W=    5.40u L=1.0u
MN1861   0      #817     #812     0      MN1      W=    5.40u L=1.0u
MN1860   0      #744     #795     0      MN1      W=    1.80u L=1.0u
MN1859   0      #742     #793     0      MN1      W=    1.80u L=1.0u
MN1858   0      #740     #791     0      MN1      W=    1.80u L=1.0u
MN1857   0      #738     #789     0      MN1      W=    1.80u L=1.0u
MN1856   0      #736     #787     0      MN1      W=    1.80u L=1.0u
MN1855   0      #734     #785     0      MN1      W=    1.80u L=1.0u
MN1854   0      #732     #783     0      MN1      W=    1.80u L=1.0u
MP1853   1      #581     #811     1      MP1      W=    1.80u L=1.0u
MN1852   0      #745     #796     0      MN1      W=    1.80u L=1.0u
MP1851   1      #745     #810     1      MP1      W=    1.80u L=1.0u
MP1850   1      #744     #809     1      MP1      W=    1.80u L=1.0u
MN1849   0      #743     #794     0      MN1      W=    1.80u L=1.0u
MP1848   1      #743     #808     1      MP1      W=    1.80u L=1.0u
MP1847   1      #742     #807     1      MP1      W=    1.80u L=1.0u
MN1846   0      #741     #792     0      MN1      W=    1.80u L=1.0u
MP1845   1      #741     #806     1      MP1      W=    1.80u L=1.0u
MP1844   1      #740     #805     1      MP1      W=    1.80u L=1.0u
MN1843   0      #739     #790     0      MN1      W=    1.80u L=1.0u
MP1842   1      #739     #804     1      MP1      W=    1.80u L=1.0u
MP1841   1      #738     #803     1      MP1      W=    1.80u L=1.0u
MN1840   0      #737     #788     0      MN1      W=    1.80u L=1.0u
MP1839   1      #737     #802     1      MP1      W=    1.80u L=1.0u
MP1838   1      #736     #801     1      MP1      W=    1.80u L=1.0u
MN1837   0      #735     #786     0      MN1      W=    1.80u L=1.0u
MP1836   1      #735     #800     1      MP1      W=    1.80u L=1.0u
MP1835   1      #734     #799     1      MP1      W=    1.80u L=1.0u
MN1834   0      #733     #784     0      MN1      W=    1.80u L=1.0u
MP1833   1      #733     #798     1      MP1      W=    1.80u L=1.0u
MP1832   1      #732     #797     1      MP1      W=    1.80u L=1.0u
MN1831   0      #581     #782     0      MN1      W=    1.80u L=1.0u
MP1830   1      #747     #817     1      MP1      W=    1.80u L=1.0u
MP1829   1      X12      #814     1      MP1      W=   10.80u L=1.0u
MN1828   0      #747     #816     0      MN1      W=    1.80u L=1.0u
MN1827   0      X12      #815     0      MN1      W=    3.60u L=1.0u
MP1826   #813     #485     1      1      MP1      W=    5.40u L=1.0u
MN1825   #812     #485     0      0      MN1      W=    5.40u L=1.0u
MP1824   #811     #582     1      1      MP1      W=    5.40u L=1.0u
MP1823   #810     #484     1      1      MP1      W=    5.40u L=1.0u
MP1822   #809     #491     1      1      MP1      W=    5.40u L=1.0u
MP1821   #808     #483     1      1      MP1      W=    5.40u L=1.0u
MP1820   #807     #490     1      1      MP1      W=    5.40u L=1.0u
MP1819   #806     #482     1      1      MP1      W=    5.40u L=1.0u
MP1818   #805     #489     1      1      MP1      W=    5.40u L=1.0u
MP1817   #804     #481     1      1      MP1      W=    5.40u L=1.0u
MP1816   #803     #488     1      1      MP1      W=    5.40u L=1.0u
MP1815   #802     #480     1      1      MP1      W=    5.40u L=1.0u
MP1814   #801     #487     1      1      MP1      W=    5.40u L=1.0u
MP1813   #800     #479     1      1      MP1      W=    5.40u L=1.0u
MP1812   #799     #486     1      1      MP1      W=    5.40u L=1.0u
MP1811   #798     #478     1      1      MP1      W=    5.40u L=1.0u
MP1810   #797     #580     1      1      MP1      W=    5.40u L=1.0u
MN1809   #796     #484     0      0      MN1      W=    5.40u L=1.0u
MN1808   #795     #491     0      0      MN1      W=    5.40u L=1.0u
MN1807   #794     #483     0      0      MN1      W=    5.40u L=1.0u
MN1806   #793     #490     0      0      MN1      W=    5.40u L=1.0u
MN1805   #792     #482     0      0      MN1      W=    5.40u L=1.0u
MN1804   #791     #489     0      0      MN1      W=    5.40u L=1.0u
MN1803   #790     #481     0      0      MN1      W=    5.40u L=1.0u
MN1802   #789     #488     0      0      MN1      W=    5.40u L=1.0u
MN1801   #788     #480     0      0      MN1      W=    5.40u L=1.0u
MN1800   #787     #487     0      0      MN1      W=    5.40u L=1.0u
MN1799   #786     #479     0      0      MN1      W=    5.40u L=1.0u
MN1798   #785     #486     0      0      MN1      W=    5.40u L=1.0u
MN1797   #784     #478     0      0      MN1      W=    5.40u L=1.0u
MN1796   #783     #580     0      0      MN1      W=    5.40u L=1.0u
MN1795   #782     #582     0      0      MN1      W=    5.40u L=1.0u
MN1794   #781     #710     0      0      MN1      W=    1.80u L=1.0u
MP1793   #781     #710     1      1      MP1      W=    1.80u L=1.0u
MN1792   #748     #814     0      0      MN1      W=    3.60u L=1.0u
MP1791   #494     #814     1      1      MP1      W=   10.80u L=1.0u
MP1790   1      #727     #813     1      MP1      W=    5.40u L=1.0u
MN1789   0      #727     #812     0      MN1      W=    5.40u L=1.0u
MP1788   1      #712     #811     1      MP1      W=    5.40u L=1.0u
MN1787   0      #726     #796     0      MN1      W=    5.40u L=1.0u
MP1786   1      #726     #810     1      MP1      W=    5.40u L=1.0u
MP1785   1      #725     #809     1      MP1      W=    5.40u L=1.0u
MN1784   0      #725     #795     0      MN1      W=    5.40u L=1.0u
MN1783   0      #724     #794     0      MN1      W=    5.40u L=1.0u
MP1782   1      #724     #808     1      MP1      W=    5.40u L=1.0u
MP1781   1      #723     #807     1      MP1      W=    5.40u L=1.0u
MN1780   0      #723     #793     0      MN1      W=    5.40u L=1.0u
MN1779   0      #722     #792     0      MN1      W=    5.40u L=1.0u
MP1778   1      #722     #806     1      MP1      W=    5.40u L=1.0u
MP1777   1      #721     #805     1      MP1      W=    5.40u L=1.0u
MN1776   0      #721     #791     0      MN1      W=    5.40u L=1.0u
MN1775   0      #720     #790     0      MN1      W=    5.40u L=1.0u
MP1774   1      #720     #804     1      MP1      W=    5.40u L=1.0u
MP1773   1      #719     #803     1      MP1      W=    5.40u L=1.0u
MN1772   0      #719     #789     0      MN1      W=    5.40u L=1.0u
MN1771   0      #718     #788     0      MN1      W=    5.40u L=1.0u
MP1770   1      #718     #802     1      MP1      W=    5.40u L=1.0u
MP1769   1      #717     #801     1      MP1      W=    5.40u L=1.0u
MN1768   0      #717     #787     0      MN1      W=    5.40u L=1.0u
MN1767   0      #716     #786     0      MN1      W=    5.40u L=1.0u
MP1766   1      #716     #800     1      MP1      W=    5.40u L=1.0u
MP1765   1      #715     #799     1      MP1      W=    5.40u L=1.0u
MN1764   0      #715     #785     0      MN1      W=    5.40u L=1.0u
MN1763   0      #714     #784     0      MN1      W=    5.40u L=1.0u
MP1762   1      #714     #798     1      MP1      W=    5.40u L=1.0u
MP1761   1      #713     #797     1      MP1      W=    5.40u L=1.0u
MN1760   0      #713     #783     0      MN1      W=    5.40u L=1.0u
MN1759   0      #712     #782     0      MN1      W=    5.40u L=1.0u
MN1758   #494     X12      #748     0      MN1      W=    3.60u L=1.0u
MP1757   #780     X12      #494     1      MP1      W=   10.80u L=1.0u
MP1756   #705     #672     1      1      MP1      W=   16.20u L=1.0u
MN1755   #673     #727     0      0      MN1      W=   10.80u L=1.0u
MP1754   #764     #712     1      1      MP1      W=    5.40u L=1.0u
MP1753   #778     #726     1      1      MP1      W=    5.40u L=1.0u
MP1752   #777     #725     1      1      MP1      W=    5.40u L=1.0u
MP1751   #776     #724     1      1      MP1      W=    5.40u L=1.0u
MP1750   #775     #723     1      1      MP1      W=    5.40u L=1.0u
MP1749   #774     #722     1      1      MP1      W=    5.40u L=1.0u
MP1748   #773     #721     1      1      MP1      W=    5.40u L=1.0u
MP1747   #772     #720     1      1      MP1      W=    5.40u L=1.0u
MP1746   #771     #719     1      1      MP1      W=    5.40u L=1.0u
MP1745   #770     #718     1      1      MP1      W=    5.40u L=1.0u
MP1744   #769     #717     1      1      MP1      W=    5.40u L=1.0u
MP1743   #768     #716     1      1      MP1      W=    5.40u L=1.0u
MP1742   #767     #715     1      1      MP1      W=    5.40u L=1.0u
MP1741   #766     #714     1      1      MP1      W=    5.40u L=1.0u
MP1740   #765     #713     1      1      MP1      W=    5.40u L=1.0u
MN1739   #763     #726     0      0      MN1      W=    5.40u L=1.0u
MN1738   #762     #725     0      0      MN1      W=    5.40u L=1.0u
MN1737   #761     #724     0      0      MN1      W=    5.40u L=1.0u
MN1736   #760     #723     0      0      MN1      W=    5.40u L=1.0u
MN1735   #759     #722     0      0      MN1      W=    5.40u L=1.0u
MN1734   #758     #721     0      0      MN1      W=    5.40u L=1.0u
MN1733   #757     #720     0      0      MN1      W=    5.40u L=1.0u
MN1732   #756     #719     0      0      MN1      W=    5.40u L=1.0u
MN1731   #755     #718     0      0      MN1      W=    5.40u L=1.0u
MN1730   #754     #717     0      0      MN1      W=    5.40u L=1.0u
MN1729   #753     #716     0      0      MN1      W=    5.40u L=1.0u
MN1728   #752     #715     0      0      MN1      W=    5.40u L=1.0u
MN1727   #751     #714     0      0      MN1      W=    5.40u L=1.0u
MN1726   #750     #713     0      0      MN1      W=    5.40u L=1.0u
MP1725   1      X11      #780     1      MP1      W=   10.80u L=1.0u
MN1724   #749     #712     0      0      MN1      W=    5.40u L=1.0u
MN1723   #748     X11      #494     0      MN1      W=    3.60u L=1.0u
MP1722   #747     #672     1      1      MP1      W=    5.40u L=1.0u
MN1721   #746     #672     #747     0      MN1      W=    5.40u L=1.0u
MP1720   #669     #484     #778     1      MP1      W=    5.40u L=1.0u
MP1719   #745     #491     #777     1      MP1      W=    5.40u L=1.0u
MP1718   #744     #483     #776     1      MP1      W=    5.40u L=1.0u
MP1717   #743     #490     #775     1      MP1      W=    5.40u L=1.0u
MP1716   #742     #482     #774     1      MP1      W=    5.40u L=1.0u
MP1715   #741     #489     #773     1      MP1      W=    5.40u L=1.0u
MP1714   #740     #481     #772     1      MP1      W=    5.40u L=1.0u
MP1713   #739     #488     #771     1      MP1      W=    5.40u L=1.0u
MP1712   #738     #480     #770     1      MP1      W=    5.40u L=1.0u
MP1711   #737     #487     #769     1      MP1      W=    5.40u L=1.0u
MP1710   #736     #479     #768     1      MP1      W=    5.40u L=1.0u
MP1709   #735     #486     #767     1      MP1      W=    5.40u L=1.0u
MP1708   #734     #478     #766     1      MP1      W=    5.40u L=1.0u
MP1707   #733     #580     #765     1      MP1      W=    5.40u L=1.0u
MP1706   #732     #582     #764     1      MP1      W=    5.40u L=1.0u
MN1705   #669     #484     #763     0      MN1      W=    5.40u L=1.0u
MN1704   #745     #491     #762     0      MN1      W=    5.40u L=1.0u
MN1703   #744     #483     #761     0      MN1      W=    5.40u L=1.0u
MN1702   #743     #490     #760     0      MN1      W=    5.40u L=1.0u
MN1701   #742     #482     #759     0      MN1      W=    5.40u L=1.0u
MN1700   #741     #489     #758     0      MN1      W=    5.40u L=1.0u
MN1699   #740     #481     #757     0      MN1      W=    5.40u L=1.0u
MN1698   #739     #488     #756     0      MN1      W=    5.40u L=1.0u
MN1697   #738     #480     #755     0      MN1      W=    5.40u L=1.0u
MN1696   #737     #487     #754     0      MN1      W=    5.40u L=1.0u
MN1695   #736     #479     #753     0      MN1      W=    5.40u L=1.0u
MN1694   #735     #486     #752     0      MN1      W=    5.40u L=1.0u
MN1693   #734     #478     #751     0      MN1      W=    5.40u L=1.0u
MN1692   #733     #580     #750     0      MN1      W=    5.40u L=1.0u
MN1691   #732     #582     #749     0      MN1      W=    5.40u L=1.0u
MP1690   1      #485     #705     1      MP1      W=   10.80u L=1.0u
MN1689   0      #485     #673     0      MN1      W=   16.20u L=1.0u
MP1688   #711     X13      1      1      MP1      W=   10.80u L=1.0u
MP1687   1      #730     #747     1      MP1      W=    5.40u L=1.0u
MN1686   0      #730     #746     0      MN1      W=    5.40u L=1.0u
MP1685   #703     #745     #669     1      MP1      W=    5.40u L=1.0u
MP1684   #702     #744     #745     1      MP1      W=    5.40u L=1.0u
MP1683   #701     #743     #744     1      MP1      W=    5.40u L=1.0u
MP1682   #700     #742     #743     1      MP1      W=    5.40u L=1.0u
MP1681   #699     #741     #742     1      MP1      W=    5.40u L=1.0u
MP1680   #698     #740     #741     1      MP1      W=    5.40u L=1.0u
MP1679   #697     #739     #740     1      MP1      W=    5.40u L=1.0u
MP1678   #696     #738     #739     1      MP1      W=    5.40u L=1.0u
MP1677   #695     #737     #738     1      MP1      W=    5.40u L=1.0u
MP1676   #694     #736     #737     1      MP1      W=    5.40u L=1.0u
MP1675   #693     #735     #736     1      MP1      W=    5.40u L=1.0u
MP1674   #692     #734     #735     1      MP1      W=    5.40u L=1.0u
MP1673   #691     #733     #734     1      MP1      W=    5.40u L=1.0u
MP1672   #690     #732     #733     1      MP1      W=    5.40u L=1.0u
MP1671   #689     #581     #732     1      MP1      W=    5.40u L=1.0u
MN1670   #688     #745     #669     0      MN1      W=    5.40u L=1.0u
MN1669   #687     #744     #745     0      MN1      W=    5.40u L=1.0u
MN1668   #686     #743     #744     0      MN1      W=    5.40u L=1.0u
MN1667   #685     #742     #743     0      MN1      W=    5.40u L=1.0u
MN1666   #684     #741     #742     0      MN1      W=    5.40u L=1.0u
MN1665   #683     #740     #741     0      MN1      W=    5.40u L=1.0u
MN1664   #682     #739     #740     0      MN1      W=    5.40u L=1.0u
MN1663   #681     #738     #739     0      MN1      W=    5.40u L=1.0u
MN1662   #680     #737     #738     0      MN1      W=    5.40u L=1.0u
MN1661   #679     #736     #737     0      MN1      W=    5.40u L=1.0u
MN1660   #678     #735     #736     0      MN1      W=    5.40u L=1.0u
MN1659   #677     #734     #735     0      MN1      W=    5.40u L=1.0u
MN1658   #676     #733     #734     0      MN1      W=    5.40u L=1.0u
MN1657   #675     #732     #733     0      MN1      W=    5.40u L=1.0u
MN1656   #674     #581     #732     0      MN1      W=    5.40u L=1.0u
MP1655   #731     #727     1      1      MP1      W=    5.40u L=1.0u
MP1653   1      X12      #711     1      MP1      W=   10.80u L=1.0u
MN1652   #729     X12      #711     0      MN1      W=    3.60u L=1.0u
MN1651   #730     #727     0      0      MN1      W=    5.40u L=1.0u
MP1650   #730     #727     1      1      MP1      W=    5.40u L=1.0u
MN1649   0      #726     #688     0      MN1      W=   16.20u L=1.0u
MP1648   1      #726     #703     1      MP1      W=   16.20u L=1.0u
MP1647   1      #725     #702     1      MP1      W=   16.20u L=1.0u
MN1646   0      #725     #687     0      MN1      W=   16.20u L=1.0u
MN1645   0      #724     #686     0      MN1      W=   16.20u L=1.0u
MP1644   1      #724     #701     1      MP1      W=   16.20u L=1.0u
MP1643   1      #723     #700     1      MP1      W=   16.20u L=1.0u
MN1642   0      #723     #685     0      MN1      W=   16.20u L=1.0u
MN1641   0      #722     #684     0      MN1      W=   16.20u L=1.0u
MP1640   1      #722     #699     1      MP1      W=   16.20u L=1.0u
MP1639   1      #721     #698     1      MP1      W=   16.20u L=1.0u
MN1638   0      #721     #683     0      MN1      W=   16.20u L=1.0u
MN1637   0      #720     #682     0      MN1      W=   16.20u L=1.0u
MP1636   1      #720     #697     1      MP1      W=   16.20u L=1.0u
MP1635   1      #719     #696     1      MP1      W=   16.20u L=1.0u
MN1634   0      #719     #681     0      MN1      W=   16.20u L=1.0u
MN1633   0      #718     #680     0      MN1      W=   16.20u L=1.0u
MP1632   1      #718     #695     1      MP1      W=   16.20u L=1.0u
MP1631   1      #717     #694     1      MP1      W=   16.20u L=1.0u
MN1630   0      #717     #679     0      MN1      W=   16.20u L=1.0u
MN1629   0      #716     #678     0      MN1      W=   16.20u L=1.0u
MP1628   1      #716     #693     1      MP1      W=   16.20u L=1.0u
MP1627   1      #715     #692     1      MP1      W=   16.20u L=1.0u
MN1626   0      #715     #677     0      MN1      W=   16.20u L=1.0u
MN1625   0      #714     #676     0      MN1      W=   16.20u L=1.0u
MP1624   1      #714     #691     1      MP1      W=   16.20u L=1.0u
MP1623   1      #713     #690     1      MP1      W=   16.20u L=1.0u
MN1622   0      #713     #675     0      MN1      W=   16.20u L=1.0u
MN1621   0      #712     #674     0      MN1      W=   16.20u L=1.0u
MP1620   1      #712     #689     1      MP1      W=   16.20u L=1.0u
MP1618   #322     #485     #731     1      MP1      W=    5.40u L=1.0u
MN1617   0      X13      #729     0      MN1      W=    3.60u L=1.0u
MP1586   #705     #710     #322     1      MP1      W=    5.40u L=1.0u
MN1584   #727     #669     0      0      MN1      W=    5.40u L=1.0u
MP1583   #728     #669     #727     1      MP1      W=    5.40u L=1.0u
MP1567   1      #711     #562     1      MP1      W=   10.80u L=1.0u
MN1551   #709     #711     0      0      MN1      W=    3.60u L=1.0u
MP1549   1      #492     #728     1      MP1      W=    5.40u L=1.0u
MN1548   #322     #710     #673     0      MN1      W=    5.40u L=1.0u
MN1547   0      #492     #727     0      MN1      W=    5.40u L=1.0u
MN1546   #670     #494     #709     0      MN1      W=    3.60u L=1.0u
MP1545   #562     #494     1      1      MP1      W=   10.80u L=1.0u
MP1543   #672     #492     1      1      MP1      W=    5.40u L=1.0u
MN1542   #706     #492     0      0      MN1      W=    5.40u L=1.0u
MN1541   #688     #484     0      0      MN1      W=   10.80u L=1.0u
MN1540   #687     #491     0      0      MN1      W=   10.80u L=1.0u
MN1539   #686     #483     0      0      MN1      W=   10.80u L=1.0u
MN1538   #685     #490     0      0      MN1      W=   10.80u L=1.0u
MN1537   #684     #482     0      0      MN1      W=   10.80u L=1.0u
MN1536   #683     #489     0      0      MN1      W=   10.80u L=1.0u
MN1535   #682     #481     0      0      MN1      W=   10.80u L=1.0u
MN1534   #681     #488     0      0      MN1      W=   10.80u L=1.0u
MN1533   #680     #480     0      0      MN1      W=   10.80u L=1.0u
MN1532   #679     #487     0      0      MN1      W=   10.80u L=1.0u
MN1531   #678     #479     0      0      MN1      W=   10.80u L=1.0u
MN1530   #677     #486     0      0      MN1      W=   10.80u L=1.0u
MN1529   #676     #478     0      0      MN1      W=   10.80u L=1.0u
MN1528   #675     #580     0      0      MN1      W=   10.80u L=1.0u
MN1527   #674     #582     0      0      MN1      W=   10.80u L=1.0u
MN1526   #707     #672     #322     0      MN1      W=    1.80u L=1.0u
MP1525   #703     #484     1      1      MP1      W=   10.80u L=1.0u
MP1524   #702     #491     1      1      MP1      W=   10.80u L=1.0u
MP1523   #701     #483     1      1      MP1      W=   10.80u L=1.0u
MP1522   #700     #490     1      1      MP1      W=   10.80u L=1.0u
MP1521   #699     #482     1      1      MP1      W=   10.80u L=1.0u
MP1520   #698     #489     1      1      MP1      W=   10.80u L=1.0u
MP1519   #697     #481     1      1      MP1      W=   10.80u L=1.0u
MP1518   #696     #488     1      1      MP1      W=   10.80u L=1.0u
MP1517   #695     #480     1      1      MP1      W=   10.80u L=1.0u
MP1516   #694     #487     1      1      MP1      W=   10.80u L=1.0u
MP1515   #693     #479     1      1      MP1      W=   10.80u L=1.0u
MP1514   #692     #486     1      1      MP1      W=   10.80u L=1.0u
MP1513   #691     #478     1      1      MP1      W=   10.80u L=1.0u
MP1512   #690     #580     1      1      MP1      W=   10.80u L=1.0u
MP1511   #689     #582     1      1      MP1      W=   10.80u L=1.0u
MN1510   #562     X12      #670     0      MN1      W=    3.60u L=1.0u
MP1509   #704     X12      #562     1      MP1      W=   10.80u L=1.0u
MN1508   #673     #485     #707     0      MN1      W=    1.80u L=1.0u
MN1507   #672     #669     #706     0      MN1      W=    5.40u L=1.0u
MP1505   1      #669     #672     1      MP1      W=    5.40u L=1.0u
MP1504   1      X13      #704     1      MP1      W=   10.80u L=1.0u
MN1473   #670     X13      #562     0      MN1      W=    3.60u L=1.0u
MN1472   0      #528     #599     0      MN1      W=    3.60u L=1.0u
MN1471   0      #527     #591     0      MN1      W=    3.60u L=1.0u
MN1470   0      #543     #598     0      MN1      W=    3.60u L=1.0u
MN1469   0      #542     #589     0      MN1      W=    3.60u L=1.0u
MN1468   0      #541     #597     0      MN1      W=    3.60u L=1.0u
MN1467   0      #540     #588     0      MN1      W=    3.60u L=1.0u
MN1466   0      #539     #596     0      MN1      W=    3.60u L=1.0u
MN1465   0      #538     #587     0      MN1      W=    3.60u L=1.0u
MN1464   0      #537     #595     0      MN1      W=    3.60u L=1.0u
MN1463   0      #536     #586     0      MN1      W=    3.60u L=1.0u
MN1462   0      #535     #594     0      MN1      W=    3.60u L=1.0u
MN1461   0      #534     #585     0      MN1      W=    3.60u L=1.0u
MN1460   0      #533     #593     0      MN1      W=    3.60u L=1.0u
MN1459   0      #532     #584     0      MN1      W=    3.60u L=1.0u
MN1458   0      #531     #592     0      MN1      W=    3.60u L=1.0u
MP1457   1      #528     #599     1      MP1      W=    3.60u L=1.0u
MP1456   1      #527     #591     1      MP1      W=    3.60u L=1.0u
MP1455   1      #543     #598     1      MP1      W=    3.60u L=1.0u
MP1454   1      #542     #589     1      MP1      W=    3.60u L=1.0u
MP1453   1      #541     #597     1      MP1      W=    3.60u L=1.0u
MP1452   1      #540     #588     1      MP1      W=    3.60u L=1.0u
MP1451   1      #539     #596     1      MP1      W=    3.60u L=1.0u
MP1450   1      #538     #587     1      MP1      W=    3.60u L=1.0u
MP1449   1      #537     #595     1      MP1      W=    3.60u L=1.0u
MP1448   1      #536     #586     1      MP1      W=    3.60u L=1.0u
MP1447   1      #535     #594     1      MP1      W=    3.60u L=1.0u
MP1446   1      #534     #585     1      MP1      W=    3.60u L=1.0u
MP1445   1      #533     #593     1      MP1      W=    3.60u L=1.0u
MP1444   1      #532     #584     1      MP1      W=    3.60u L=1.0u
MP1443   1      #531     #592     1      MP1      W=    3.60u L=1.0u
MP1442   1      #530     #583     1      MP1      W=    3.60u L=1.0u
MN1441   0      #530     #583     0      MN1      W=    3.60u L=1.0u
MP1440   1      #544     #590     1      MP1      W=    3.60u L=1.0u
MP1439   #634     #582     1      1      MP1      W=   21.60u L=1.0u
MN1438   0      #544     #590     0      MN1      W=    3.60u L=1.0u
MN1437   #634     #582     0      0      MN1      W=    7.20u L=1.0u
MP1434   #668     #599     1      1      MP1      W=    3.60u L=1.0u
MP1433   #667     #591     1      1      MP1      W=    3.60u L=1.0u
MP1432   #666     #543     1      1      MP1      W=    3.60u L=1.0u
MP1431   #665     #589     1      1      MP1      W=    3.60u L=1.0u
MP1430   #664     #541     1      1      MP1      W=    3.60u L=1.0u
MP1429   #663     #588     1      1      MP1      W=    3.60u L=1.0u
MP1428   #662     #539     1      1      MP1      W=    3.60u L=1.0u
MP1427   #661     #587     1      1      MP1      W=    3.60u L=1.0u
MP1426   #660     #537     1      1      MP1      W=    3.60u L=1.0u
MP1425   #659     #586     1      1      MP1      W=    3.60u L=1.0u
MP1424   #658     #535     1      1      MP1      W=    3.60u L=1.0u
MP1423   #657     #585     1      1      MP1      W=    3.60u L=1.0u
MP1422   #656     #533     1      1      MP1      W=    3.60u L=1.0u
MP1421   #655     #584     1      1      MP1      W=    3.60u L=1.0u
MP1420   #654     #531     1      1      MP1      W=    3.60u L=1.0u
MP1419   #653     #583     1      1      MP1      W=    3.60u L=1.0u
MP1418   #652     #544     1      1      MP1      W=    3.60u L=1.0u
MN1417   #651     #528     0      0      MN1      W=    3.60u L=1.0u
MN1416   #650     #527     0      0      MN1      W=    3.60u L=1.0u
MN1415   #649     #598     0      0      MN1      W=    3.60u L=1.0u
MN1414   #648     #542     0      0      MN1      W=    3.60u L=1.0u
MN1413   #647     #597     0      0      MN1      W=    3.60u L=1.0u
MN1412   #646     #540     0      0      MN1      W=    3.60u L=1.0u
MN1411   #645     #596     0      0      MN1      W=    3.60u L=1.0u
MN1410   #644     #538     0      0      MN1      W=    3.60u L=1.0u
MN1409   #643     #595     0      0      MN1      W=    3.60u L=1.0u
MN1408   #642     #536     0      0      MN1      W=    3.60u L=1.0u
MN1407   #641     #594     0      0      MN1      W=    3.60u L=1.0u
MN1406   #640     #534     0      0      MN1      W=    3.60u L=1.0u
MN1405   #639     #593     0      0      MN1      W=    3.60u L=1.0u
MN1404   #638     #532     0      0      MN1      W=    3.60u L=1.0u
MN1403   #637     #592     0      0      MN1      W=    3.60u L=1.0u
MN1402   #636     #530     0      0      MN1      W=    3.60u L=1.0u
MN1401   #635     #590     0      0      MN1      W=    3.60u L=1.0u
MP1400   #578     #634     #668     1      MP1      W=    3.60u L=1.0u
MP1399   #577     #634     #667     1      MP1      W=    3.60u L=1.0u
MP1398   #576     #634     #666     1      MP1      W=    3.60u L=1.0u
MP1397   #575     #634     #665     1      MP1      W=    3.60u L=1.0u
MP1396   #574     #634     #664     1      MP1      W=    3.60u L=1.0u
MP1395   #573     #634     #663     1      MP1      W=    3.60u L=1.0u
MP1394   #572     #634     #662     1      MP1      W=    3.60u L=1.0u
MP1393   #571     #634     #661     1      MP1      W=    3.60u L=1.0u
MP1392   #570     #634     #660     1      MP1      W=    3.60u L=1.0u
MP1391   #569     #634     #659     1      MP1      W=    3.60u L=1.0u
MP1390   #568     #634     #658     1      MP1      W=    3.60u L=1.0u
MP1389   #567     #634     #657     1      MP1      W=    3.60u L=1.0u
MP1388   #566     #634     #656     1      MP1      W=    3.60u L=1.0u
MP1387   #565     #634     #655     1      MP1      W=    3.60u L=1.0u
MP1386   #564     #634     #654     1      MP1      W=    3.60u L=1.0u
MP1385   #563     #634     #653     1      MP1      W=    3.60u L=1.0u
MN1384   #578     #634     #651     0      MN1      W=    3.60u L=1.0u
MN1383   #577     #634     #650     0      MN1      W=    3.60u L=1.0u
MN1382   #576     #634     #649     0      MN1      W=    3.60u L=1.0u
MN1381   #575     #634     #648     0      MN1      W=    3.60u L=1.0u
MN1380   #574     #634     #647     0      MN1      W=    3.60u L=1.0u
MN1379   #573     #634     #646     0      MN1      W=    3.60u L=1.0u
MN1378   #572     #634     #645     0      MN1      W=    3.60u L=1.0u
MN1377   #571     #634     #644     0      MN1      W=    3.60u L=1.0u
MN1376   #570     #634     #643     0      MN1      W=    3.60u L=1.0u
MN1375   #569     #634     #642     0      MN1      W=    3.60u L=1.0u
MN1374   #568     #634     #641     0      MN1      W=    3.60u L=1.0u
MN1373   #567     #634     #640     0      MN1      W=    3.60u L=1.0u
MN1372   #566     #634     #639     0      MN1      W=    3.60u L=1.0u
MN1371   #565     #634     #638     0      MN1      W=    3.60u L=1.0u
MN1370   #564     #634     #637     0      MN1      W=    3.60u L=1.0u
MN1369   #563     #634     #636     0      MN1      W=    3.60u L=1.0u
MP1368   #579     #634     #652     1      MP1      W=    3.60u L=1.0u
MN1367   #579     #634     #635     0      MN1      W=    3.60u L=1.0u
MP1366   #582     X13      1      1      MP1      W=   21.60u L=1.0u
MN1365   #582     X13      0      0      MN1      W=    7.20u L=1.0u
MN1364   #616     #582     #578     0      MN1      W=    3.60u L=1.0u
MP1363   #633     #582     #578     1      MP1      W=    3.60u L=1.0u
MP1362   #631     #582     #577     1      MP1      W=    3.60u L=1.0u
MN1361   #614     #582     #576     0      MN1      W=    3.60u L=1.0u
MP1360   #630     #582     #576     1      MP1      W=    3.60u L=1.0u
MP1359   #629     #582     #575     1      MP1      W=    3.60u L=1.0u
MN1358   #612     #582     #574     0      MN1      W=    3.60u L=1.0u
MP1357   #628     #582     #574     1      MP1      W=    3.60u L=1.0u
MP1356   #627     #582     #573     1      MP1      W=    3.60u L=1.0u
MN1355   #610     #582     #572     0      MN1      W=    3.60u L=1.0u
MP1354   #626     #582     #572     1      MP1      W=    3.60u L=1.0u
MP1353   #625     #582     #571     1      MP1      W=    3.60u L=1.0u
MN1352   #608     #582     #570     0      MN1      W=    3.60u L=1.0u
MP1351   #624     #582     #570     1      MP1      W=    3.60u L=1.0u
MP1350   #623     #582     #569     1      MP1      W=    3.60u L=1.0u
MN1349   #606     #582     #568     0      MN1      W=    3.60u L=1.0u
MP1348   #622     #582     #568     1      MP1      W=    3.60u L=1.0u
MP1347   #621     #582     #567     1      MP1      W=    3.60u L=1.0u
MN1346   #604     #582     #566     0      MN1      W=    3.60u L=1.0u
MP1345   #620     #582     #566     1      MP1      W=    3.60u L=1.0u
MP1344   #619     #582     #565     1      MP1      W=    3.60u L=1.0u
MN1343   #602     #582     #564     0      MN1      W=    3.60u L=1.0u
MP1342   #618     #582     #564     1      MP1      W=    3.60u L=1.0u
MP1341   #617     #582     #563     1      MP1      W=    3.60u L=1.0u
MN1340   #601     #582     #563     0      MN1      W=    3.60u L=1.0u
MN1339   #615     #582     #577     0      MN1      W=    3.60u L=1.0u
MN1338   #613     #582     #575     0      MN1      W=    3.60u L=1.0u
MN1337   #611     #582     #573     0      MN1      W=    3.60u L=1.0u
MN1336   #609     #582     #571     0      MN1      W=    3.60u L=1.0u
MN1335   #607     #582     #569     0      MN1      W=    3.60u L=1.0u
MN1334   #605     #582     #567     0      MN1      W=    3.60u L=1.0u
MN1333   #603     #582     #565     0      MN1      W=    3.60u L=1.0u
MN1332   #600     #582     #579     0      MN1      W=    3.60u L=1.0u
MP1331   #632     #582     #579     1      MP1      W=    3.60u L=1.0u
MP1328   1      #528     #633     1      MP1      W=    3.60u L=1.0u
MP1327   1      #590     #632     1      MP1      W=    3.60u L=1.0u
MN1326   0      #599     #616     0      MN1      W=    3.60u L=1.0u
MP1325   1      #527     #631     1      MP1      W=    3.60u L=1.0u
MN1324   0      #591     #615     0      MN1      W=    3.60u L=1.0u
MN1323   0      #543     #614     0      MN1      W=    3.60u L=1.0u
MP1322   1      #598     #630     1      MP1      W=    3.60u L=1.0u
MP1321   1      #542     #629     1      MP1      W=    3.60u L=1.0u
MN1320   0      #589     #613     0      MN1      W=    3.60u L=1.0u
MN1319   0      #541     #612     0      MN1      W=    3.60u L=1.0u
MP1318   1      #597     #628     1      MP1      W=    3.60u L=1.0u
MP1317   1      #540     #627     1      MP1      W=    3.60u L=1.0u
MN1316   0      #588     #611     0      MN1      W=    3.60u L=1.0u
MN1315   0      #539     #610     0      MN1      W=    3.60u L=1.0u
MP1314   1      #596     #626     1      MP1      W=    3.60u L=1.0u
MP1313   1      #538     #625     1      MP1      W=    3.60u L=1.0u
MN1312   0      #587     #609     0      MN1      W=    3.60u L=1.0u
MN1311   0      #537     #608     0      MN1      W=    3.60u L=1.0u
MP1310   1      #595     #624     1      MP1      W=    3.60u L=1.0u
MP1309   1      #536     #623     1      MP1      W=    3.60u L=1.0u
MN1308   0      #586     #607     0      MN1      W=    3.60u L=1.0u
MN1307   0      #535     #606     0      MN1      W=    3.60u L=1.0u
MP1306   1      #594     #622     1      MP1      W=    3.60u L=1.0u
MP1305   1      #534     #621     1      MP1      W=    3.60u L=1.0u
MN1304   0      #585     #605     0      MN1      W=    3.60u L=1.0u
MN1303   0      #533     #604     0      MN1      W=    3.60u L=1.0u
MP1302   1      #593     #620     1      MP1      W=    3.60u L=1.0u
MP1301   1      #532     #619     1      MP1      W=    3.60u L=1.0u
MN1300   0      #584     #603     0      MN1      W=    3.60u L=1.0u
MN1299   0      #531     #602     0      MN1      W=    3.60u L=1.0u
MP1298   1      #592     #618     1      MP1      W=    3.60u L=1.0u
MP1297   1      #530     #617     1      MP1      W=    3.60u L=1.0u
MN1296   0      #583     #601     0      MN1      W=    3.60u L=1.0u
MN1295   0      #544     #600     0      MN1      W=    3.60u L=1.0u
MN1294   #529     #562     0      0      MN1      W=   14.40u L=1.0u
MP1293   #529     #562     1      1      MP1      W=   43.20u L=1.0u
MP1292   #581     #579     1      1      MP1      W=   10.80u L=1.0u
MN1291   #303     #578     0      0      MN1      W=   10.80u L=1.0u
MN1290   #302     #577     0      0      MN1      W=   10.80u L=1.0u
MN1289   #301     #576     0      0      MN1      W=   10.80u L=1.0u
MN1288   #300     #575     0      0      MN1      W=   10.80u L=1.0u
MN1287   #299     #574     0      0      MN1      W=   10.80u L=1.0u
MN1286   #298     #573     0      0      MN1      W=   10.80u L=1.0u
MN1285   #297     #572     0      0      MN1      W=   10.80u L=1.0u
MN1284   #296     #571     0      0      MN1      W=   10.80u L=1.0u
MN1283   #295     #570     0      0      MN1      W=   10.80u L=1.0u
MN1282   #294     #569     0      0      MN1      W=   10.80u L=1.0u
MN1281   #293     #568     0      0      MN1      W=   10.80u L=1.0u
MN1280   #292     #567     0      0      MN1      W=   10.80u L=1.0u
MN1279   #291     #566     0      0      MN1      W=   10.80u L=1.0u
MN1278   #290     #565     0      0      MN1      W=   10.80u L=1.0u
MN1277   #289     #564     0      0      MN1      W=   10.80u L=1.0u
MN1276   #580     #563     0      0      MN1      W=   10.80u L=1.0u
MN1275   #581     #579     0      0      MN1      W=   10.80u L=1.0u
MP1274   #303     #578     1      1      MP1      W=   10.80u L=1.0u
MP1273   #302     #577     1      1      MP1      W=   10.80u L=1.0u
MP1272   #301     #576     1      1      MP1      W=   10.80u L=1.0u
MP1271   #300     #575     1      1      MP1      W=   10.80u L=1.0u
MP1270   #299     #574     1      1      MP1      W=   10.80u L=1.0u
MP1269   #298     #573     1      1      MP1      W=   10.80u L=1.0u
MP1268   #297     #572     1      1      MP1      W=   10.80u L=1.0u
MP1267   #296     #571     1      1      MP1      W=   10.80u L=1.0u
MP1266   #295     #570     1      1      MP1      W=   10.80u L=1.0u
MP1265   #294     #569     1      1      MP1      W=   10.80u L=1.0u
MP1264   #293     #568     1      1      MP1      W=   10.80u L=1.0u
MP1263   #292     #567     1      1      MP1      W=   10.80u L=1.0u
MP1262   #291     #566     1      1      MP1      W=   10.80u L=1.0u
MP1261   #290     #565     1      1      MP1      W=   10.80u L=1.0u
MP1260   #289     #564     1      1      MP1      W=   10.80u L=1.0u
MP1259   #580     #563     1      1      MP1      W=   10.80u L=1.0u
MP1220   #496     #529     1      1      MP1      W=    3.60u L=1.0u
MP1219   #495     #529     1      1      MP1      W=    3.60u L=1.0u
MP1218   #511     #529     1      1      MP1      W=    3.60u L=1.0u
MP1217   #510     #529     1      1      MP1      W=    3.60u L=1.0u
MP1216   #509     #529     1      1      MP1      W=    3.60u L=1.0u
MP1215   #508     #529     1      1      MP1      W=    3.60u L=1.0u
MP1214   #507     #529     1      1      MP1      W=    3.60u L=1.0u
MP1213   #506     #529     1      1      MP1      W=    3.60u L=1.0u
MP1212   #505     #529     1      1      MP1      W=    3.60u L=1.0u
MP1211   #504     #529     1      1      MP1      W=    3.60u L=1.0u
MP1210   #503     #529     1      1      MP1      W=    3.60u L=1.0u
MP1209   #502     #529     1      1      MP1      W=    3.60u L=1.0u
MP1208   #501     #529     1      1      MP1      W=    3.60u L=1.0u
MP1207   #500     #529     1      1      MP1      W=    3.60u L=1.0u
MP1206   #499     #529     1      1      MP1      W=    3.60u L=1.0u
MP1205   #498     #529     1      1      MP1      W=    3.60u L=1.0u
MP1204   #544     #493     1      1      MP1      W=    3.60u L=1.0u
MN1203   #561     #493     0      0      MN1      W=    3.60u L=1.0u
MN1202   #560     #493     0      0      MN1      W=    3.60u L=1.0u
MN1201   #559     #493     0      0      MN1      W=    3.60u L=1.0u
MN1200   #558     #493     0      0      MN1      W=    3.60u L=1.0u
MN1199   #557     #493     0      0      MN1      W=    3.60u L=1.0u
MN1198   #556     #493     0      0      MN1      W=    3.60u L=1.0u
MN1197   #555     #493     0      0      MN1      W=    3.60u L=1.0u
MN1196   #554     #493     0      0      MN1      W=    3.60u L=1.0u
MN1195   #553     #493     0      0      MN1      W=    3.60u L=1.0u
MN1194   #552     #493     0      0      MN1      W=    3.60u L=1.0u
MN1193   #551     #493     0      0      MN1      W=    3.60u L=1.0u
MN1192   #550     #493     0      0      MN1      W=    3.60u L=1.0u
MN1191   #549     #493     0      0      MN1      W=    3.60u L=1.0u
MN1190   #548     #493     0      0      MN1      W=    3.60u L=1.0u
MN1189   #547     #493     0      0      MN1      W=    3.60u L=1.0u
MN1188   #546     #493     0      0      MN1      W=    3.60u L=1.0u
MN1185   #545     #493     0      0      MN1      W=    3.60u L=1.0u
MP1184   #543     #51      #511     1      MP1      W=    3.60u L=1.0u
MP1183   #542     #50      #510     1      MP1      W=    3.60u L=1.0u
MP1182   #541     #49      #509     1      MP1      W=    3.60u L=1.0u
MP1181   #540     #48      #508     1      MP1      W=    3.60u L=1.0u
MP1180   #539     #47      #507     1      MP1      W=    3.60u L=1.0u
MP1179   #538     #46      #506     1      MP1      W=    3.60u L=1.0u
MP1178   #537     #45      #505     1      MP1      W=    3.60u L=1.0u
MP1177   #536     #44      #504     1      MP1      W=    3.60u L=1.0u
MP1176   #535     #43      #503     1      MP1      W=    3.60u L=1.0u
MP1175   #534     #42      #502     1      MP1      W=    3.60u L=1.0u
MP1174   #533     #41      #501     1      MP1      W=    3.60u L=1.0u
MP1173   #532     #40      #500     1      MP1      W=    3.60u L=1.0u
MP1172   #531     #39      #499     1      MP1      W=    3.60u L=1.0u
MP1171   #530     #38      #498     1      MP1      W=    3.60u L=1.0u
MN1170   #527     #52      #561     0      MN1      W=    3.60u L=1.0u
MN1169   #543     #51      #560     0      MN1      W=    3.60u L=1.0u
MN1168   #542     #50      #559     0      MN1      W=    3.60u L=1.0u
MN1167   #541     #49      #558     0      MN1      W=    3.60u L=1.0u
MN1166   #540     #48      #557     0      MN1      W=    3.60u L=1.0u
MN1165   #539     #47      #556     0      MN1      W=    3.60u L=1.0u
MN1164   #538     #46      #555     0      MN1      W=    3.60u L=1.0u
MN1163   #537     #45      #554     0      MN1      W=    3.60u L=1.0u
MN1162   #536     #44      #553     0      MN1      W=    3.60u L=1.0u
MN1161   #535     #43      #552     0      MN1      W=    3.60u L=1.0u
MN1160   #534     #42      #551     0      MN1      W=    3.60u L=1.0u
MN1159   #533     #41      #550     0      MN1      W=    3.60u L=1.0u
MN1158   #532     #40      #549     0      MN1      W=    3.60u L=1.0u
MN1157   #531     #39      #548     0      MN1      W=    3.60u L=1.0u
MN1156   #530     #38      #547     0      MN1      W=    3.60u L=1.0u
MN1155   #544     #37      #546     0      MN1      W=    3.60u L=1.0u
MP1154   1      #37      #544     1      MP1      W=    3.60u L=1.0u
MP1153   #527     #52      #495     1      MP1      W=    3.60u L=1.0u
MP1152   #528     #52      #496     1      MP1      W=    3.60u L=1.0u
MN1151   #493     #494     0      0      MN1      W=   14.40u L=1.0u
MN1150   #528     #52      #545     0      MN1      W=    3.60u L=1.0u
MP1149   #493     #494     1      1      MP1      W=   43.20u L=1.0u
MN1148   #526     #529     #527     0      MN1      W=    3.60u L=1.0u
MN1147   #525     #529     #543     0      MN1      W=    3.60u L=1.0u
MN1146   #524     #529     #542     0      MN1      W=    3.60u L=1.0u
MN1145   #523     #529     #541     0      MN1      W=    3.60u L=1.0u
MN1144   #522     #529     #540     0      MN1      W=    3.60u L=1.0u
MN1143   #521     #529     #539     0      MN1      W=    3.60u L=1.0u
MN1142   #520     #529     #538     0      MN1      W=    3.60u L=1.0u
MN1141   #519     #529     #537     0      MN1      W=    3.60u L=1.0u
MN1140   #518     #529     #536     0      MN1      W=    3.60u L=1.0u
MN1139   #517     #529     #535     0      MN1      W=    3.60u L=1.0u
MN1138   #516     #529     #534     0      MN1      W=    3.60u L=1.0u
MN1137   #515     #529     #533     0      MN1      W=    3.60u L=1.0u
MN1136   #514     #529     #532     0      MN1      W=    3.60u L=1.0u
MN1135   #513     #529     #531     0      MN1      W=    3.60u L=1.0u
MP1134   #511     #493     #543     1      MP1      W=    3.60u L=1.0u
MP1133   #510     #493     #542     1      MP1      W=    3.60u L=1.0u
MP1132   #509     #493     #541     1      MP1      W=    3.60u L=1.0u
MP1131   #508     #493     #540     1      MP1      W=    3.60u L=1.0u
MP1130   #507     #493     #539     1      MP1      W=    3.60u L=1.0u
MP1129   #506     #493     #538     1      MP1      W=    3.60u L=1.0u
MP1128   #505     #493     #537     1      MP1      W=    3.60u L=1.0u
MP1127   #504     #493     #536     1      MP1      W=    3.60u L=1.0u
MP1126   #503     #493     #535     1      MP1      W=    3.60u L=1.0u
MP1125   #502     #493     #534     1      MP1      W=    3.60u L=1.0u
MP1124   #501     #493     #533     1      MP1      W=    3.60u L=1.0u
MP1123   #500     #493     #532     1      MP1      W=    3.60u L=1.0u
MP1122   #499     #493     #531     1      MP1      W=    3.60u L=1.0u
MP1121   #498     #493     #530     1      MP1      W=    3.60u L=1.0u
MN1120   #512     #529     #530     0      MN1      W=    3.60u L=1.0u
MN1119   #497     #529     #528     0      MN1      W=    3.60u L=1.0u
MP1116   #496     #493     #528     1      MP1      W=    3.60u L=1.0u
MP1115   #495     #493     #527     1      MP1      W=    3.60u L=1.0u
MN1114   0      #51      #526     0      MN1      W=    3.60u L=1.0u
MN1113   0      #50      #525     0      MN1      W=    3.60u L=1.0u
MN1112   0      #49      #524     0      MN1      W=    3.60u L=1.0u
MN1111   0      #48      #523     0      MN1      W=    3.60u L=1.0u
MN1110   0      #47      #522     0      MN1      W=    3.60u L=1.0u
MN1109   0      #46      #521     0      MN1      W=    3.60u L=1.0u
MN1108   0      #45      #520     0      MN1      W=    3.60u L=1.0u
MN1107   0      #44      #519     0      MN1      W=    3.60u L=1.0u
MN1106   0      #43      #518     0      MN1      W=    3.60u L=1.0u
MN1105   0      #42      #517     0      MN1      W=    3.60u L=1.0u
MN1104   0      #41      #516     0      MN1      W=    3.60u L=1.0u
MN1103   0      #40      #515     0      MN1      W=    3.60u L=1.0u
MN1102   0      #39      #514     0      MN1      W=    3.60u L=1.0u
MN1101   0      #38      #513     0      MN1      W=    3.60u L=1.0u
MN1100   0      #37      #512     0      MN1      W=    3.60u L=1.0u
MP1099   1      #50      #511     1      MP1      W=    3.60u L=1.0u
MP1098   1      #49      #510     1      MP1      W=    3.60u L=1.0u
MP1097   1      #48      #509     1      MP1      W=    3.60u L=1.0u
MP1096   1      #47      #508     1      MP1      W=    3.60u L=1.0u
MP1095   1      #46      #507     1      MP1      W=    3.60u L=1.0u
MP1094   1      #45      #506     1      MP1      W=    3.60u L=1.0u
MP1093   1      #44      #505     1      MP1      W=    3.60u L=1.0u
MP1092   1      #43      #504     1      MP1      W=    3.60u L=1.0u
MP1091   1      #42      #503     1      MP1      W=    3.60u L=1.0u
MP1090   1      #41      #502     1      MP1      W=    3.60u L=1.0u
MP1089   1      #40      #501     1      MP1      W=    3.60u L=1.0u
MP1088   1      #39      #500     1      MP1      W=    3.60u L=1.0u
MP1087   1      #38      #499     1      MP1      W=    3.60u L=1.0u
MP1086   1      #37      #498     1      MP1      W=    3.60u L=1.0u
MN1085   0      #52      #497     0      MN1      W=    3.60u L=1.0u
MP1084   1      #52      #496     1      MP1      W=    3.60u L=1.0u
MP1083   1      #51      #495     1      MP1      W=    3.60u L=1.0u
MN1080   #478     #395     0      0      MN1      W=   10.80u L=1.0u
MP1079   #478     #395     1      1      MP1      W=   10.80u L=1.0u
MN1078   #485     #402     0      0      MN1      W=   10.80u L=1.0u
MN1077   #492     #409     0      0      MN1      W=   10.80u L=1.0u
MN1076   #484     #401     0      0      MN1      W=   10.80u L=1.0u
MN1075   #491     #408     0      0      MN1      W=   10.80u L=1.0u
MN1074   #483     #400     0      0      MN1      W=   10.80u L=1.0u
MN1073   #490     #407     0      0      MN1      W=   10.80u L=1.0u
MN1072   #482     #399     0      0      MN1      W=   10.80u L=1.0u
MN1071   #489     #406     0      0      MN1      W=   10.80u L=1.0u
MN1070   #481     #398     0      0      MN1      W=   10.80u L=1.0u
MN1069   #488     #405     0      0      MN1      W=   10.80u L=1.0u
MN1068   #480     #397     0      0      MN1      W=   10.80u L=1.0u
MN1067   #487     #404     0      0      MN1      W=   10.80u L=1.0u
MN1066   #479     #396     0      0      MN1      W=   10.80u L=1.0u
MN1065   #486     #403     0      0      MN1      W=   10.80u L=1.0u
MP1064   #485     #402     1      1      MP1      W=   10.80u L=1.0u
MP1063   #492     #409     1      1      MP1      W=   10.80u L=1.0u
MP1062   #484     #401     1      1      MP1      W=   10.80u L=1.0u
MP1061   #491     #408     1      1      MP1      W=   10.80u L=1.0u
MP1060   #483     #400     1      1      MP1      W=   10.80u L=1.0u
MP1059   #490     #407     1      1      MP1      W=   10.80u L=1.0u
MP1058   #482     #399     1      1      MP1      W=   10.80u L=1.0u
MP1057   #489     #406     1      1      MP1      W=   10.80u L=1.0u
MP1056   #481     #398     1      1      MP1      W=   10.80u L=1.0u
MP1055   #488     #405     1      1      MP1      W=   10.80u L=1.0u
MP1054   #480     #397     1      1      MP1      W=   10.80u L=1.0u
MP1053   #487     #404     1      1      MP1      W=   10.80u L=1.0u
MP1052   #479     #396     1      1      MP1      W=   10.80u L=1.0u
MP1051   #486     #403     1      1      MP1      W=   10.80u L=1.0u
MN1032   0      #322     #458     0      MN1      W=    1.80u L=1.0u
MN1017   Z29      #410     0      0      MN1      W=    3.60u L=1.0u
MP1016   #477     #323     1      1      MP1      W=    1.80u L=1.0u
MP1015   Z29      #410     1      1      MP1      W=    3.60u L=1.0u
MN1014   #443     #289     0      0      MN1      W=    5.40u L=1.0u
MP1013   #474     #289     1      1      MP1      W=    5.40u L=1.0u
MN1012   #458     #323     0      0      MN1      W=    1.80u L=1.0u
MN1011   #457     #303     0      0      MN1      W=    5.40u L=1.0u
MN1010   #455     #301     0      0      MN1      W=    5.40u L=1.0u
MN1009   #453     #299     0      0      MN1      W=    5.40u L=1.0u
MN1008   #451     #297     0      0      MN1      W=    5.40u L=1.0u
MN1007   #449     #295     0      0      MN1      W=    5.40u L=1.0u
MN1006   #447     #293     0      0      MN1      W=    5.40u L=1.0u
MN1005   #445     #291     0      0      MN1      W=    5.40u L=1.0u
MP1004   #473     #303     1      1      MP1      W=    5.40u L=1.0u
MP1003   #471     #301     1      1      MP1      W=    5.40u L=1.0u
MP1002   #469     #299     1      1      MP1      W=    5.40u L=1.0u
MP1001   #467     #297     1      1      MP1      W=    5.40u L=1.0u
MP1000   #465     #295     1      1      MP1      W=    5.40u L=1.0u
MP999    #463     #293     1      1      MP1      W=    5.40u L=1.0u
MP998    #461     #291     1      1      MP1      W=    5.40u L=1.0u
MP997    #475     #54      1      1      MP1      W=    5.40u L=1.0u
MP996    #410     #322     #477     1      MP1      W=    1.80u L=1.0u
MP995    #472     #302     1      1      MP1      W=    5.40u L=1.0u
MP994    #470     #300     1      1      MP1      W=    5.40u L=1.0u
MP993    #468     #298     1      1      MP1      W=    5.40u L=1.0u
MP992    #466     #296     1      1      MP1      W=    5.40u L=1.0u
MP991    #464     #294     1      1      MP1      W=    5.40u L=1.0u
MP990    #462     #292     1      1      MP1      W=    5.40u L=1.0u
MP989    #460     #290     1      1      MP1      W=    5.40u L=1.0u
MN988    #456     #302     0      0      MN1      W=    5.40u L=1.0u
MN987    #454     #300     0      0      MN1      W=    5.40u L=1.0u
MN986    #452     #298     0      0      MN1      W=    5.40u L=1.0u
MN985    #450     #296     0      0      MN1      W=    5.40u L=1.0u
MN984    #448     #294     0      0      MN1      W=    5.40u L=1.0u
MN983    #446     #292     0      0      MN1      W=    5.40u L=1.0u
MN982    #444     #290     0      0      MN1      W=    5.40u L=1.0u
MN981    #459     #54      0      0      MN1      W=    5.40u L=1.0u
MP980    #442     #286     #475     1      MP1      W=    5.40u L=1.0u
MP979    #440     #123     #474     1      MP1      W=    5.40u L=1.0u
MP978    #439     #155     #473     1      MP1      W=    5.40u L=1.0u
MP977    #438     #154     #472     1      MP1      W=    5.40u L=1.0u
MP976    #437     #153     #471     1      MP1      W=    5.40u L=1.0u
MP975    #436     #152     #470     1      MP1      W=    5.40u L=1.0u
MP974    #435     #151     #469     1      MP1      W=    5.40u L=1.0u
MP973    #434     #150     #468     1      MP1      W=    5.40u L=1.0u
MP972    #433     #149     #467     1      MP1      W=    5.40u L=1.0u
MP971    #432     #148     #466     1      MP1      W=    5.40u L=1.0u
MP970    #431     #147     #465     1      MP1      W=    5.40u L=1.0u
MP969    #430     #146     #464     1      MP1      W=    5.40u L=1.0u
MP968    #429     #145     #463     1      MP1      W=    5.40u L=1.0u
MP967    #428     #144     #462     1      MP1      W=    5.40u L=1.0u
MP966    #427     #143     #461     1      MP1      W=    5.40u L=1.0u
MP965    #426     #142     #460     1      MP1      W=    5.40u L=1.0u
MN964    #441     #286     #459     0      MN1      W=    5.40u L=1.0u
MN963    #410     #392     #458     0      MN1      W=    1.80u L=1.0u
MN962    #425     #155     #457     0      MN1      W=    5.40u L=1.0u
MN961    #424     #154     #456     0      MN1      W=    5.40u L=1.0u
MN960    #423     #153     #455     0      MN1      W=    5.40u L=1.0u
MN959    #422     #152     #454     0      MN1      W=    5.40u L=1.0u
MN958    #421     #151     #453     0      MN1      W=    5.40u L=1.0u
MN957    #420     #150     #452     0      MN1      W=    5.40u L=1.0u
MN956    #419     #149     #451     0      MN1      W=    5.40u L=1.0u
MN955    #418     #148     #450     0      MN1      W=    5.40u L=1.0u
MN954    #417     #147     #449     0      MN1      W=    5.40u L=1.0u
MN953    #416     #146     #448     0      MN1      W=    5.40u L=1.0u
MN952    #415     #145     #447     0      MN1      W=    5.40u L=1.0u
MN951    #414     #144     #446     0      MN1      W=    5.40u L=1.0u
MN950    #413     #143     #445     0      MN1      W=    5.40u L=1.0u
MN949    #412     #142     #444     0      MN1      W=    5.40u L=1.0u
MN948    #411     #123     #443     0      MN1      W=    5.40u L=1.0u
MP947    1      #392     #410     1      MP1      W=    1.80u L=1.0u
MN946    Z30      #392     #441     0      MN1      W=    5.40u L=1.0u
MP945    Z30      #392     #442     1      MP1      W=    5.40u L=1.0u
MP944    #395     #141     #440     1      MP1      W=    1.80u L=1.0u
MN943    #402     #321     #425     0      MN1      W=    1.80u L=1.0u
MP942    #402     #321     #439     1      MP1      W=    1.80u L=1.0u
MP941    #409     #320     #438     1      MP1      W=    1.80u L=1.0u
MN940    #409     #320     #424     0      MN1      W=    1.80u L=1.0u
MN939    #401     #319     #423     0      MN1      W=    1.80u L=1.0u
MP938    #401     #319     #437     1      MP1      W=    1.80u L=1.0u
MP937    #408     #318     #436     1      MP1      W=    1.80u L=1.0u
MN936    #408     #318     #422     0      MN1      W=    1.80u L=1.0u
MN935    #400     #317     #421     0      MN1      W=    1.80u L=1.0u
MP934    #400     #317     #435     1      MP1      W=    1.80u L=1.0u
MP933    #407     #316     #434     1      MP1      W=    1.80u L=1.0u
MN932    #407     #316     #420     0      MN1      W=    1.80u L=1.0u
MN931    #399     #315     #419     0      MN1      W=    1.80u L=1.0u
MP930    #399     #315     #433     1      MP1      W=    1.80u L=1.0u
MP929    #406     #314     #432     1      MP1      W=    1.80u L=1.0u
MN928    #406     #314     #418     0      MN1      W=    1.80u L=1.0u
MN927    #398     #313     #417     0      MN1      W=    1.80u L=1.0u
MP926    #398     #313     #431     1      MP1      W=    1.80u L=1.0u
MP925    #405     #312     #430     1      MP1      W=    1.80u L=1.0u
MN924    #405     #312     #416     0      MN1      W=    1.80u L=1.0u
MN923    #397     #311     #415     0      MN1      W=    1.80u L=1.0u
MP922    #397     #311     #429     1      MP1      W=    1.80u L=1.0u
MP921    #404     #310     #428     1      MP1      W=    1.80u L=1.0u
MN920    #404     #310     #414     0      MN1      W=    1.80u L=1.0u
MN919    #396     #309     #413     0      MN1      W=    1.80u L=1.0u
MP918    #396     #309     #427     1      MP1      W=    1.80u L=1.0u
MP917    #403     #308     #426     1      MP1      W=    1.80u L=1.0u
MN916    #403     #308     #412     0      MN1      W=    1.80u L=1.0u
MN915    #395     #141     #411     0      MN1      W=    1.80u L=1.0u
MP914    #359     #360     Z30      1      MP1      W=    1.80u L=1.0u
MP913    #392     #322     1      1      MP1      W=    1.80u L=1.0u
MN912    #358     #360     Z30      0      MN1      W=    1.80u L=1.0u
MN911    #374     #321     #409     0      MN1      W=    1.80u L=1.0u
MN910    #372     #319     #408     0      MN1      W=    1.80u L=1.0u
MN909    #370     #317     #407     0      MN1      W=    1.80u L=1.0u
MN908    #368     #315     #406     0      MN1      W=    1.80u L=1.0u
MN907    #366     #313     #405     0      MN1      W=    1.80u L=1.0u
MN906    #364     #311     #404     0      MN1      W=    1.80u L=1.0u
MN905    #362     #309     #403     0      MN1      W=    1.80u L=1.0u
MP904    #390     #308     #395     1      MP1      W=    1.80u L=1.0u
MP903    #389     #244     #402     1      MP1      W=    1.80u L=1.0u
MP902    #388     #321     #409     1      MP1      W=    1.80u L=1.0u
MP901    #387     #320     #401     1      MP1      W=    1.80u L=1.0u
MP900    #386     #319     #408     1      MP1      W=    1.80u L=1.0u
MP899    #385     #318     #400     1      MP1      W=    1.80u L=1.0u
MP898    #384     #317     #407     1      MP1      W=    1.80u L=1.0u
MP897    #383     #316     #399     1      MP1      W=    1.80u L=1.0u
MP896    #382     #315     #406     1      MP1      W=    1.80u L=1.0u
MP895    #381     #314     #398     1      MP1      W=    1.80u L=1.0u
MP894    #380     #313     #405     1      MP1      W=    1.80u L=1.0u
MP893    #379     #312     #397     1      MP1      W=    1.80u L=1.0u
MP892    #378     #311     #404     1      MP1      W=    1.80u L=1.0u
MP891    #377     #310     #396     1      MP1      W=    1.80u L=1.0u
MP890    #376     #309     #403     1      MP1      W=    1.80u L=1.0u
MN889    #375     #244     #402     0      MN1      W=    1.80u L=1.0u
MN888    #373     #320     #401     0      MN1      W=    1.80u L=1.0u
MN887    #371     #318     #400     0      MN1      W=    1.80u L=1.0u
MN886    #369     #316     #399     0      MN1      W=    1.80u L=1.0u
MN885    #367     #314     #398     0      MN1      W=    1.80u L=1.0u
MN884    #365     #312     #397     0      MN1      W=    1.80u L=1.0u
MN883    #363     #310     #396     0      MN1      W=    1.80u L=1.0u
MN882    #361     #308     #395     0      MN1      W=    1.80u L=1.0u
MP881    #391     X13      1      1      MP1      W=   10.80u L=1.0u
MN880    #394     X13      #391     0      MN1      W=    3.60u L=1.0u
MN879    #393     #322     #392     0      MN1      W=    1.80u L=1.0u
MN878    0      #320     #374     0      MN1      W=    1.80u L=1.0u
MN877    0      #318     #372     0      MN1      W=    1.80u L=1.0u
MN876    0      #316     #370     0      MN1      W=    1.80u L=1.0u
MN875    0      #314     #368     0      MN1      W=    1.80u L=1.0u
MN874    0      #312     #366     0      MN1      W=    1.80u L=1.0u
MN873    0      #310     #364     0      MN1      W=    1.80u L=1.0u
MN872    0      #308     #362     0      MN1      W=    1.80u L=1.0u
MP871    1      #141     #390     1      MP1      W=    1.80u L=1.0u
MN870    0      #321     #375     0      MN1      W=    1.80u L=1.0u
MP869    1      #321     #389     1      MP1      W=    1.80u L=1.0u
MP868    1      #320     #388     1      MP1      W=    1.80u L=1.0u
MN867    0      #319     #373     0      MN1      W=    1.80u L=1.0u
MP866    1      #319     #387     1      MP1      W=    1.80u L=1.0u
MP865    1      #318     #386     1      MP1      W=    1.80u L=1.0u
MN864    0      #317     #371     0      MN1      W=    1.80u L=1.0u
MP863    1      #317     #385     1      MP1      W=    1.80u L=1.0u
MP862    1      #316     #384     1      MP1      W=    1.80u L=1.0u
MN861    0      #315     #369     0      MN1      W=    1.80u L=1.0u
MP860    1      #315     #383     1      MP1      W=    1.80u L=1.0u
MP859    1      #314     #382     1      MP1      W=    1.80u L=1.0u
MN858    0      #313     #367     0      MN1      W=    1.80u L=1.0u
MP857    1      #313     #381     1      MP1      W=    1.80u L=1.0u
MP856    1      #312     #380     1      MP1      W=    1.80u L=1.0u
MN855    0      #311     #365     0      MN1      W=    1.80u L=1.0u
MP854    1      #311     #379     1      MP1      W=    1.80u L=1.0u
MP853    1      #310     #378     1      MP1      W=    1.80u L=1.0u
MN852    0      #309     #363     0      MN1      W=    1.80u L=1.0u
MP851    1      #309     #377     1      MP1      W=    1.80u L=1.0u
MP850    1      #308     #376     1      MP1      W=    1.80u L=1.0u
MN849    0      #141     #361     0      MN1      W=    1.80u L=1.0u
MN848    0      #392     #358     0      MN1      W=    5.40u L=1.0u
MP847    1      #392     #359     1      MP1      W=    5.40u L=1.0u
MP846    1      X14      #391     1      MP1      W=   10.80u L=1.0u
MP845    1      #323     #392     1      MP1      W=    1.80u L=1.0u
MN844    0      X14      #394     0      MN1      W=    3.60u L=1.0u
MN843    0      #323     #393     0      MN1      W=    1.80u L=1.0u
MP842    #390     #123     1      1      MP1      W=    5.40u L=1.0u
MP841    #389     #155     1      1      MP1      W=    5.40u L=1.0u
MP840    #388     #154     1      1      MP1      W=    5.40u L=1.0u
MP839    #387     #153     1      1      MP1      W=    5.40u L=1.0u
MP838    #386     #152     1      1      MP1      W=    5.40u L=1.0u
MP837    #385     #151     1      1      MP1      W=    5.40u L=1.0u
MP836    #384     #150     1      1      MP1      W=    5.40u L=1.0u
MP835    #383     #149     1      1      MP1      W=    5.40u L=1.0u
MP834    #382     #148     1      1      MP1      W=    5.40u L=1.0u
MP833    #381     #147     1      1      MP1      W=    5.40u L=1.0u
MP832    #380     #146     1      1      MP1      W=    5.40u L=1.0u
MP831    #379     #145     1      1      MP1      W=    5.40u L=1.0u
MP830    #378     #144     1      1      MP1      W=    5.40u L=1.0u
MP829    #377     #143     1      1      MP1      W=    5.40u L=1.0u
MP828    #376     #142     1      1      MP1      W=    5.40u L=1.0u
MN827    #375     #155     0      0      MN1      W=    5.40u L=1.0u
MN826    #374     #154     0      0      MN1      W=    5.40u L=1.0u
MN825    #373     #153     0      0      MN1      W=    5.40u L=1.0u
MN824    #372     #152     0      0      MN1      W=    5.40u L=1.0u
MN823    #371     #151     0      0      MN1      W=    5.40u L=1.0u
MN822    #370     #150     0      0      MN1      W=    5.40u L=1.0u
MN821    #369     #149     0      0      MN1      W=    5.40u L=1.0u
MN820    #368     #148     0      0      MN1      W=    5.40u L=1.0u
MN819    #367     #147     0      0      MN1      W=    5.40u L=1.0u
MN818    #366     #146     0      0      MN1      W=    5.40u L=1.0u
MN817    #365     #145     0      0      MN1      W=    5.40u L=1.0u
MN816    #364     #144     0      0      MN1      W=    5.40u L=1.0u
MN815    #363     #143     0      0      MN1      W=    5.40u L=1.0u
MN814    #362     #142     0      0      MN1      W=    5.40u L=1.0u
MN813    #361     #123     0      0      MN1      W=    5.40u L=1.0u
MN812    #325     #391     0      0      MN1      W=    3.60u L=1.0u
MN811    #360     Z31      0      0      MN1      W=    1.80u L=1.0u
MP810    #36      #391     1      1      MP1      W=   10.80u L=1.0u
MP809    #359     #54      1      1      MP1      W=    5.40u L=1.0u
MP808    #360     Z31      1      1      MP1      W=    1.80u L=1.0u
MN807    #358     #54      0      0      MN1      W=    5.40u L=1.0u
MP806    1      #289     #390     1      MP1      W=    5.40u L=1.0u
MN805    0      #303     #375     0      MN1      W=    5.40u L=1.0u
MP804    1      #303     #389     1      MP1      W=    5.40u L=1.0u
MP803    1      #302     #388     1      MP1      W=    5.40u L=1.0u
MN802    0      #302     #374     0      MN1      W=    5.40u L=1.0u
MN801    0      #301     #373     0      MN1      W=    5.40u L=1.0u
MP800    1      #301     #387     1      MP1      W=    5.40u L=1.0u
MP799    1      #300     #386     1      MP1      W=    5.40u L=1.0u
MN798    0      #300     #372     0      MN1      W=    5.40u L=1.0u
MN797    0      #299     #371     0      MN1      W=    5.40u L=1.0u
MP796    1      #299     #385     1      MP1      W=    5.40u L=1.0u
MP795    1      #298     #384     1      MP1      W=    5.40u L=1.0u
MN794    0      #298     #370     0      MN1      W=    5.40u L=1.0u
MN793    0      #297     #369     0      MN1      W=    5.40u L=1.0u
MP792    1      #297     #383     1      MP1      W=    5.40u L=1.0u
MP791    1      #296     #382     1      MP1      W=    5.40u L=1.0u
MN790    0      #296     #368     0      MN1      W=    5.40u L=1.0u
MN789    0      #295     #367     0      MN1      W=    5.40u L=1.0u
MP788    1      #295     #381     1      MP1      W=    5.40u L=1.0u
MP787    1      #294     #380     1      MP1      W=    5.40u L=1.0u
MN786    0      #294     #366     0      MN1      W=    5.40u L=1.0u
MN785    0      #293     #365     0      MN1      W=    5.40u L=1.0u
MP784    1      #293     #379     1      MP1      W=    5.40u L=1.0u
MP783    1      #292     #378     1      MP1      W=    5.40u L=1.0u
MN782    0      #292     #364     0      MN1      W=    5.40u L=1.0u
MN781    0      #291     #363     0      MN1      W=    5.40u L=1.0u
MP780    1      #291     #377     1      MP1      W=    5.40u L=1.0u
MP779    1      #290     #376     1      MP1      W=    5.40u L=1.0u
MN778    0      #290     #362     0      MN1      W=    5.40u L=1.0u
MN777    0      #289     #361     0      MN1      W=    5.40u L=1.0u
MN776    #36      X14      #325     0      MN1      W=    3.60u L=1.0u
MP775    #357     X14      #36      1      MP1      W=   10.80u L=1.0u
MP774    1      #286     #359     1      MP1      W=    5.40u L=1.0u
MN773    0      #286     #358     0      MN1      W=    5.40u L=1.0u
MP772    #341     #289     1      1      MP1      W=    5.40u L=1.0u
MP771    #355     #303     1      1      MP1      W=    5.40u L=1.0u
MP770    #354     #302     1      1      MP1      W=    5.40u L=1.0u
MP769    #353     #301     1      1      MP1      W=    5.40u L=1.0u
MP768    #352     #300     1      1      MP1      W=    5.40u L=1.0u
MP767    #351     #299     1      1      MP1      W=    5.40u L=1.0u
MP766    #350     #298     1      1      MP1      W=    5.40u L=1.0u
MP765    #349     #297     1      1      MP1      W=    5.40u L=1.0u
MP764    #348     #296     1      1      MP1      W=    5.40u L=1.0u
MP763    #347     #295     1      1      MP1      W=    5.40u L=1.0u
MP762    #346     #294     1      1      MP1      W=    5.40u L=1.0u
MP761    #345     #293     1      1      MP1      W=    5.40u L=1.0u
MP760    #344     #292     1      1      MP1      W=    5.40u L=1.0u
MP759    #343     #291     1      1      MP1      W=    5.40u L=1.0u
MP758    #342     #290     1      1      MP1      W=    5.40u L=1.0u
MN757    #340     #303     0      0      MN1      W=    5.40u L=1.0u
MN756    #339     #302     0      0      MN1      W=    5.40u L=1.0u
MN755    #338     #301     0      0      MN1      W=    5.40u L=1.0u
MN754    #337     #300     0      0      MN1      W=    5.40u L=1.0u
MN753    #336     #299     0      0      MN1      W=    5.40u L=1.0u
MN752    #335     #298     0      0      MN1      W=    5.40u L=1.0u
MN751    #334     #297     0      0      MN1      W=    5.40u L=1.0u
MN750    #333     #296     0      0      MN1      W=    5.40u L=1.0u
MN749    #332     #295     0      0      MN1      W=    5.40u L=1.0u
MN748    #331     #294     0      0      MN1      W=    5.40u L=1.0u
MN747    #330     #293     0      0      MN1      W=    5.40u L=1.0u
MN746    #329     #292     0      0      MN1      W=    5.40u L=1.0u
MN745    #328     #291     0      0      MN1      W=    5.40u L=1.0u
MN744    #327     #290     0      0      MN1      W=    5.40u L=1.0u
MP743    1      X13      #357     1      MP1      W=   10.80u L=1.0u
MN742    #326     #289     0      0      MN1      W=    5.40u L=1.0u
MN741    #325     X13      #36      0      MN1      W=    3.60u L=1.0u
MN740    Z31      #284     0      0      MN1      W=    1.80u L=1.0u
MP739    #306     #284     1      1      MP1      W=    5.40u L=1.0u
MP738    #323     #246     1      1      MP1      W=    5.40u L=1.0u
MN737    #324     #246     #323     0      MN1      W=    5.40u L=1.0u
MP736    #244     #155     #355     1      MP1      W=    5.40u L=1.0u
MP735    #321     #154     #354     1      MP1      W=    5.40u L=1.0u
MP734    #320     #153     #353     1      MP1      W=    5.40u L=1.0u
MP733    #319     #152     #352     1      MP1      W=    5.40u L=1.0u
MP732    #318     #151     #351     1      MP1      W=    5.40u L=1.0u
MP731    #317     #150     #350     1      MP1      W=    5.40u L=1.0u
MP730    #316     #149     #349     1      MP1      W=    5.40u L=1.0u
MP729    #315     #148     #348     1      MP1      W=    5.40u L=1.0u
MP728    #314     #147     #347     1      MP1      W=    5.40u L=1.0u
MP727    #313     #146     #346     1      MP1      W=    5.40u L=1.0u
MP726    #312     #145     #345     1      MP1      W=    5.40u L=1.0u
MP725    #311     #144     #344     1      MP1      W=    5.40u L=1.0u
MP724    #310     #143     #343     1      MP1      W=    5.40u L=1.0u
MP723    #309     #142     #342     1      MP1      W=    5.40u L=1.0u
MP722    #308     #123     #341     1      MP1      W=    5.40u L=1.0u
MN721    #244     #155     #340     0      MN1      W=    5.40u L=1.0u
MN720    #321     #154     #339     0      MN1      W=    5.40u L=1.0u
MN719    #320     #153     #338     0      MN1      W=    5.40u L=1.0u
MN718    #319     #152     #337     0      MN1      W=    5.40u L=1.0u
MN717    #318     #151     #336     0      MN1      W=    5.40u L=1.0u
MN716    #317     #150     #335     0      MN1      W=    5.40u L=1.0u
MN715    #316     #149     #334     0      MN1      W=    5.40u L=1.0u
MN714    #315     #148     #333     0      MN1      W=    5.40u L=1.0u
MN713    #314     #147     #332     0      MN1      W=    5.40u L=1.0u
MN712    #313     #146     #331     0      MN1      W=    5.40u L=1.0u
MN711    #312     #145     #330     0      MN1      W=    5.40u L=1.0u
MN710    #311     #144     #329     0      MN1      W=    5.40u L=1.0u
MN709    #310     #143     #328     0      MN1      W=    5.40u L=1.0u
MN708    #309     #142     #327     0      MN1      W=    5.40u L=1.0u
MN707    #308     #123     #326     0      MN1      W=    5.40u L=1.0u
MP706    #288     X15      1      1      MP1      W=   10.80u L=1.0u
MN705    0      #304     #324     0      MN1      W=    5.40u L=1.0u
MP704    Z31      #322     #306     1      MP1      W=    5.40u L=1.0u
MP703    1      #304     #323     1      MP1      W=    5.40u L=1.0u
MN702    #307     #322     Z31      0      MN1      W=    5.40u L=1.0u
MP701    #278     #321     #244     1      MP1      W=    5.40u L=1.0u
MP700    #277     #320     #321     1      MP1      W=    5.40u L=1.0u
MP699    #276     #319     #320     1      MP1      W=    5.40u L=1.0u
MP698    #275     #318     #319     1      MP1      W=    5.40u L=1.0u
MP697    #274     #317     #318     1      MP1      W=    5.40u L=1.0u
MP696    #273     #316     #317     1      MP1      W=    5.40u L=1.0u
MP695    #272     #315     #316     1      MP1      W=    5.40u L=1.0u
MP694    #271     #314     #315     1      MP1      W=    5.40u L=1.0u
MP693    #270     #313     #314     1      MP1      W=    5.40u L=1.0u
MP692    #269     #312     #313     1      MP1      W=    5.40u L=1.0u
MP691    #268     #311     #312     1      MP1      W=    5.40u L=1.0u
MP690    #267     #310     #311     1      MP1      W=    5.40u L=1.0u
MP689    #266     #309     #310     1      MP1      W=    5.40u L=1.0u
MP688    #265     #308     #309     1      MP1      W=    5.40u L=1.0u
MP687    #264     #141     #308     1      MP1      W=    5.40u L=1.0u
MN686    #263     #321     #244     0      MN1      W=    5.40u L=1.0u
MN685    #262     #320     #321     0      MN1      W=    5.40u L=1.0u
MN684    #261     #319     #320     0      MN1      W=    5.40u L=1.0u
MN683    #260     #318     #319     0      MN1      W=    5.40u L=1.0u
MN682    #259     #317     #318     0      MN1      W=    5.40u L=1.0u
MN681    #258     #316     #317     0      MN1      W=    5.40u L=1.0u
MN680    #257     #315     #316     0      MN1      W=    5.40u L=1.0u
MN679    #256     #314     #315     0      MN1      W=    5.40u L=1.0u
MN678    #255     #313     #314     0      MN1      W=    5.40u L=1.0u
MN677    #254     #312     #313     0      MN1      W=    5.40u L=1.0u
MN676    #253     #311     #312     0      MN1      W=    5.40u L=1.0u
MN675    #252     #310     #311     0      MN1      W=    5.40u L=1.0u
MN674    #251     #309     #310     0      MN1      W=    5.40u L=1.0u
MN673    #250     #308     #309     0      MN1      W=    5.40u L=1.0u
MN672    #249     #141     #308     0      MN1      W=    5.40u L=1.0u
MP671    1      X14      #288     1      MP1      W=   10.80u L=1.0u
MN670    #305     X14      #288     0      MN1      W=    3.60u L=1.0u
MN669    #304     #286     0      0      MN1      W=    5.40u L=1.0u
MN668    0      #247     #307     0      MN1      W=    5.40u L=1.0u
MP667    #306     #247     Z31      1      MP1      W=    1.80u L=1.0u
MP666    #304     #286     1      1      MP1      W=    5.40u L=1.0u
MN665    0      #303     #263     0      MN1      W=   16.20u L=1.0u
MP664    1      #303     #278     1      MP1      W=   16.20u L=1.0u
MP663    1      #302     #277     1      MP1      W=   16.20u L=1.0u
MN662    0      #302     #262     0      MN1      W=   16.20u L=1.0u
MN661    0      #301     #261     0      MN1      W=   16.20u L=1.0u
MP660    1      #301     #276     1      MP1      W=   16.20u L=1.0u
MP659    1      #300     #275     1      MP1      W=   16.20u L=1.0u
MN658    0      #300     #260     0      MN1      W=   16.20u L=1.0u
MN657    0      #299     #259     0      MN1      W=   16.20u L=1.0u
MP656    1      #299     #274     1      MP1      W=   16.20u L=1.0u
MP655    1      #298     #273     1      MP1      W=   16.20u L=1.0u
MN654    0      #298     #258     0      MN1      W=   16.20u L=1.0u
MN653    0      #297     #257     0      MN1      W=   16.20u L=1.0u
MP652    1      #297     #272     1      MP1      W=   16.20u L=1.0u
MP651    1      #296     #271     1      MP1      W=   16.20u L=1.0u
MN650    0      #296     #256     0      MN1      W=   16.20u L=1.0u
MN649    0      #295     #255     0      MN1      W=   16.20u L=1.0u
MP648    1      #295     #270     1      MP1      W=   16.20u L=1.0u
MP647    1      #294     #269     1      MP1      W=   16.20u L=1.0u
MN646    0      #294     #254     0      MN1      W=   16.20u L=1.0u
MN645    0      #293     #253     0      MN1      W=   16.20u L=1.0u
MP644    1      #293     #268     1      MP1      W=   16.20u L=1.0u
MP643    1      #292     #267     1      MP1      W=   16.20u L=1.0u
MN642    0      #292     #252     0      MN1      W=   16.20u L=1.0u
MN641    0      #291     #251     0      MN1      W=   16.20u L=1.0u
MP640    1      #291     #266     1      MP1      W=   16.20u L=1.0u
MP639    1      #290     #265     1      MP1      W=   16.20u L=1.0u
MN638    0      #290     #250     0      MN1      W=   16.20u L=1.0u
MN637    0      #289     #249     0      MN1      W=   16.20u L=1.0u
MP636    1      #289     #264     1      MP1      W=   16.20u L=1.0u
MN635    0      X15      #305     0      MN1      W=    3.60u L=1.0u
MN604    #284     #286     0      0      MN1      W=    5.40u L=1.0u
MN603    #286     #244     0      0      MN1      W=    5.40u L=1.0u
MP602    #287     #244     #286     1      MP1      W=    5.40u L=1.0u
MP586    1      #288     #105     1      MP1      W=   10.80u L=1.0u
MP585    #285     #286     #284     1      MP1      W=    5.40u L=1.0u
MN569    #283     #288     0      0      MN1      W=    3.60u L=1.0u
MP568    1      #156     #287     1      MP1      W=    5.40u L=1.0u
MN567    0      #156     #286     0      MN1      W=    5.40u L=1.0u
MP566    1      #54      #285     1      MP1      W=    5.40u L=1.0u
MN565    0      #54      #284     0      MN1      W=    5.40u L=1.0u
MN564    #245     #36      #283     0      MN1      W=    3.60u L=1.0u
MP563    #105     #36      1      1      MP1      W=   10.80u L=1.0u
MN562    #279     #156     0      0      MN1      W=    5.40u L=1.0u
MN561    #263     #155     0      0      MN1      W=   10.80u L=1.0u
MN560    #262     #154     0      0      MN1      W=   10.80u L=1.0u
MN559    #261     #153     0      0      MN1      W=   10.80u L=1.0u
MN558    #260     #152     0      0      MN1      W=   10.80u L=1.0u
MN557    #259     #151     0      0      MN1      W=   10.80u L=1.0u
MN556    #258     #150     0      0      MN1      W=   10.80u L=1.0u
MN555    #257     #149     0      0      MN1      W=   10.80u L=1.0u
MN554    #256     #148     0      0      MN1      W=   10.80u L=1.0u
MN553    #255     #147     0      0      MN1      W=   10.80u L=1.0u
MN552    #254     #146     0      0      MN1      W=   10.80u L=1.0u
MN551    #253     #145     0      0      MN1      W=   10.80u L=1.0u
MN550    #252     #144     0      0      MN1      W=   10.80u L=1.0u
MN549    #251     #143     0      0      MN1      W=   10.80u L=1.0u
MN548    #250     #142     0      0      MN1      W=   10.80u L=1.0u
MN547    #249     #123     0      0      MN1      W=   10.80u L=1.0u
MP546    #246     #156     1      1      MP1      W=    5.40u L=1.0u
MP545    #278     #155     1      1      MP1      W=   10.80u L=1.0u
MP544    #277     #154     1      1      MP1      W=   10.80u L=1.0u
MP543    #276     #153     1      1      MP1      W=   10.80u L=1.0u
MP542    #275     #152     1      1      MP1      W=   10.80u L=1.0u
MP541    #274     #151     1      1      MP1      W=   10.80u L=1.0u
MP540    #273     #150     1      1      MP1      W=   10.80u L=1.0u
MP539    #272     #149     1      1      MP1      W=   10.80u L=1.0u
MP538    #271     #148     1      1      MP1      W=   10.80u L=1.0u
MP537    #270     #147     1      1      MP1      W=   10.80u L=1.0u
MP536    #269     #146     1      1      MP1      W=   10.80u L=1.0u
MP535    #268     #145     1      1      MP1      W=   10.80u L=1.0u
MP534    #267     #144     1      1      MP1      W=   10.80u L=1.0u
MP533    #266     #143     1      1      MP1      W=   10.80u L=1.0u
MP532    #265     #142     1      1      MP1      W=   10.80u L=1.0u
MP531    #264     #123     1      1      MP1      W=   10.80u L=1.0u
MP530    #247     #246     1      1      MP1      W=    5.40u L=1.0u
MN529    #281     #246     0      0      MN1      W=    5.40u L=1.0u
MN528    #105     X14      #245     0      MN1      W=    3.60u L=1.0u
MP527    #280     X14      #105     1      MP1      W=   10.80u L=1.0u
MN526    #247     #54      #281     0      MN1      W=    5.40u L=1.0u
MP525    1      #54      #247     1      MP1      W=    5.40u L=1.0u
MN524    #246     #244     #279     0      MN1      W=    5.40u L=1.0u
MP523    1      X15      #280     1      MP1      W=   10.80u L=1.0u
MP522    1      #244     #246     1      MP1      W=    5.40u L=1.0u
MN491    #245     X15      #105     0      MN1      W=    3.60u L=1.0u
MN490    0      #88      #173     0      MN1      W=    3.60u L=1.0u
MP489    1      #88      #173     1      MP1      W=    3.60u L=1.0u
MP488    1      #103     #164     1      MP1      W=    3.60u L=1.0u
MP487    1      #104     #165     1      MP1      W=    3.60u L=1.0u
MN486    0      #103     #164     0      MN1      W=    3.60u L=1.0u
MP485    1      #102     #172     1      MP1      W=    3.60u L=1.0u
MP484    1      #101     #163     1      MP1      W=    3.60u L=1.0u
MP483    1      #100     #171     1      MP1      W=    3.60u L=1.0u
MP482    1      #99      #162     1      MP1      W=    3.60u L=1.0u
MP481    1      #98      #170     1      MP1      W=    3.60u L=1.0u
MP480    1      #97      #161     1      MP1      W=    3.60u L=1.0u
MP479    1      #96      #169     1      MP1      W=    3.60u L=1.0u
MP478    1      #95      #160     1      MP1      W=    3.60u L=1.0u
MP477    1      #94      #168     1      MP1      W=    3.60u L=1.0u
MP476    1      #93      #159     1      MP1      W=    3.60u L=1.0u
MP475    1      #92      #167     1      MP1      W=    3.60u L=1.0u
MP474    1      #91      #158     1      MP1      W=    3.60u L=1.0u
MP473    1      #90      #166     1      MP1      W=    3.60u L=1.0u
MP472    1      #89      #157     1      MP1      W=    3.60u L=1.0u
MN471    0      #104     #165     0      MN1      W=    3.60u L=1.0u
MP470    #209     #123     1      1      MP1      W=   21.60u L=1.0u
MN469    0      #102     #172     0      MN1      W=    3.60u L=1.0u
MN468    0      #101     #163     0      MN1      W=    3.60u L=1.0u
MN467    0      #100     #171     0      MN1      W=    3.60u L=1.0u
MN466    0      #99      #162     0      MN1      W=    3.60u L=1.0u
MN465    0      #98      #170     0      MN1      W=    3.60u L=1.0u
MN464    0      #97      #161     0      MN1      W=    3.60u L=1.0u
MN463    0      #96      #169     0      MN1      W=    3.60u L=1.0u
MN462    0      #95      #160     0      MN1      W=    3.60u L=1.0u
MN461    0      #94      #168     0      MN1      W=    3.60u L=1.0u
MN460    0      #93      #159     0      MN1      W=    3.60u L=1.0u
MN459    0      #92      #167     0      MN1      W=    3.60u L=1.0u
MN458    0      #91      #158     0      MN1      W=    3.60u L=1.0u
MN457    0      #90      #166     0      MN1      W=    3.60u L=1.0u
MN456    0      #89      #157     0      MN1      W=    3.60u L=1.0u
MN455    #209     #123     0      0      MN1      W=    7.20u L=1.0u
MN453    #243     #88      0      0      MN1      W=    3.60u L=1.0u
MP451    #242     #173     1      1      MP1      W=    3.60u L=1.0u
MP450    #225     #104     1      1      MP1      W=    3.60u L=1.0u
MP449    #241     #164     1      1      MP1      W=    3.60u L=1.0u
MP448    #240     #163     1      1      MP1      W=    3.60u L=1.0u
MP447    #239     #162     1      1      MP1      W=    3.60u L=1.0u
MP446    #238     #161     1      1      MP1      W=    3.60u L=1.0u
MP445    #237     #160     1      1      MP1      W=    3.60u L=1.0u
MP444    #236     #159     1      1      MP1      W=    3.60u L=1.0u
MP443    #235     #158     1      1      MP1      W=    3.60u L=1.0u
MP442    #234     #157     1      1      MP1      W=    3.60u L=1.0u
MN441    #233     #165     0      0      MN1      W=    3.60u L=1.0u
MP440    #232     #102     1      1      MP1      W=    3.60u L=1.0u
MP439    #231     #100     1      1      MP1      W=    3.60u L=1.0u
MP438    #230     #98      1      1      MP1      W=    3.60u L=1.0u
MP437    #229     #96      1      1      MP1      W=    3.60u L=1.0u
MP436    #228     #94      1      1      MP1      W=    3.60u L=1.0u
MP435    #227     #92      1      1      MP1      W=    3.60u L=1.0u
MP434    #226     #90      1      1      MP1      W=    3.60u L=1.0u
MN433    #224     #103     0      0      MN1      W=    3.60u L=1.0u
MN432    #223     #101     0      0      MN1      W=    3.60u L=1.0u
MN431    #222     #99      0      0      MN1      W=    3.60u L=1.0u
MN430    #221     #97      0      0      MN1      W=    3.60u L=1.0u
MN429    #220     #95      0      0      MN1      W=    3.60u L=1.0u
MN428    #219     #93      0      0      MN1      W=    3.60u L=1.0u
MN427    #218     #91      0      0      MN1      W=    3.60u L=1.0u
MN426    #217     #89      0      0      MN1      W=    3.60u L=1.0u
MN425    #216     #172     0      0      MN1      W=    3.60u L=1.0u
MN424    #215     #171     0      0      MN1      W=    3.60u L=1.0u
MN423    #214     #170     0      0      MN1      W=    3.60u L=1.0u
MN422    #213     #169     0      0      MN1      W=    3.60u L=1.0u
MN421    #212     #168     0      0      MN1      W=    3.60u L=1.0u
MN420    #211     #167     0      0      MN1      W=    3.60u L=1.0u
MN419    #210     #166     0      0      MN1      W=    3.60u L=1.0u
MN418    #124     #209     #243     0      MN1      W=    3.60u L=1.0u
MP417    #124     #209     #242     1      MP1      W=    3.60u L=1.0u
MN416    #125     #209     #233     0      MN1      W=    3.60u L=1.0u
MP415    #140     #209     #241     1      MP1      W=    3.60u L=1.0u
MP414    #138     #209     #240     1      MP1      W=    3.60u L=1.0u
MP413    #136     #209     #239     1      MP1      W=    3.60u L=1.0u
MP412    #134     #209     #238     1      MP1      W=    3.60u L=1.0u
MP411    #132     #209     #237     1      MP1      W=    3.60u L=1.0u
MP410    #130     #209     #236     1      MP1      W=    3.60u L=1.0u
MP409    #128     #209     #235     1      MP1      W=    3.60u L=1.0u
MP408    #126     #209     #234     1      MP1      W=    3.60u L=1.0u
MN407    #140     #209     #224     0      MN1      W=    3.60u L=1.0u
MP406    #139     #209     #232     1      MP1      W=    3.60u L=1.0u
MN405    #138     #209     #223     0      MN1      W=    3.60u L=1.0u
MP404    #137     #209     #231     1      MP1      W=    3.60u L=1.0u
MN403    #136     #209     #222     0      MN1      W=    3.60u L=1.0u
MP402    #135     #209     #230     1      MP1      W=    3.60u L=1.0u
MN401    #134     #209     #221     0      MN1      W=    3.60u L=1.0u
MP400    #133     #209     #229     1      MP1      W=    3.60u L=1.0u
MN399    #132     #209     #220     0      MN1      W=    3.60u L=1.0u
MP398    #131     #209     #228     1      MP1      W=    3.60u L=1.0u
MN397    #130     #209     #219     0      MN1      W=    3.60u L=1.0u
MP396    #129     #209     #227     1      MP1      W=    3.60u L=1.0u
MN395    #128     #209     #218     0      MN1      W=    3.60u L=1.0u
MP394    #127     #209     #226     1      MP1      W=    3.60u L=1.0u
MN393    #126     #209     #217     0      MN1      W=    3.60u L=1.0u
MP392    #125     #209     #225     1      MP1      W=    3.60u L=1.0u
MN391    #139     #209     #216     0      MN1      W=    3.60u L=1.0u
MN390    #137     #209     #215     0      MN1      W=    3.60u L=1.0u
MN389    #135     #209     #214     0      MN1      W=    3.60u L=1.0u
MN388    #133     #209     #213     0      MN1      W=    3.60u L=1.0u
MN387    #131     #209     #212     0      MN1      W=    3.60u L=1.0u
MN386    #129     #209     #211     0      MN1      W=    3.60u L=1.0u
MN385    #127     #209     #210     0      MN1      W=    3.60u L=1.0u
MN384    #123     X15      0      0      MN1      W=    7.20u L=1.0u
MP383    #123     X15      1      1      MP1      W=   21.60u L=1.0u
MN382    #208     #123     #124     0      MN1      W=    3.60u L=1.0u
MP381    #206     #123     #124     1      MP1      W=    3.60u L=1.0u
MP380    #204     #123     #140     1      MP1      W=    3.60u L=1.0u
MN379    #189     #123     #140     0      MN1      W=    3.60u L=1.0u
MP378    #202     #123     #138     1      MP1      W=    3.60u L=1.0u
MP377    #200     #123     #136     1      MP1      W=    3.60u L=1.0u
MP376    #198     #123     #134     1      MP1      W=    3.60u L=1.0u
MP375    #196     #123     #132     1      MP1      W=    3.60u L=1.0u
MP374    #194     #123     #130     1      MP1      W=    3.60u L=1.0u
MP373    #192     #123     #128     1      MP1      W=    3.60u L=1.0u
MP372    #190     #123     #126     1      MP1      W=    3.60u L=1.0u
MN371    #188     #123     #139     0      MN1      W=    3.60u L=1.0u
MP370    #203     #123     #139     1      MP1      W=    3.60u L=1.0u
MN369    #187     #123     #138     0      MN1      W=    3.60u L=1.0u
MN368    #186     #123     #137     0      MN1      W=    3.60u L=1.0u
MP367    #201     #123     #137     1      MP1      W=    3.60u L=1.0u
MN366    #185     #123     #136     0      MN1      W=    3.60u L=1.0u
MN365    #184     #123     #135     0      MN1      W=    3.60u L=1.0u
MP364    #199     #123     #135     1      MP1      W=    3.60u L=1.0u
MN363    #183     #123     #134     0      MN1      W=    3.60u L=1.0u
MN362    #182     #123     #133     0      MN1      W=    3.60u L=1.0u
MP361    #197     #123     #133     1      MP1      W=    3.60u L=1.0u
MN360    #181     #123     #132     0      MN1      W=    3.60u L=1.0u
MN359    #180     #123     #131     0      MN1      W=    3.60u L=1.0u
MP358    #195     #123     #131     1      MP1      W=    3.60u L=1.0u
MN357    #179     #123     #130     0      MN1      W=    3.60u L=1.0u
MN356    #178     #123     #129     0      MN1      W=    3.60u L=1.0u
MP355    #193     #123     #129     1      MP1      W=    3.60u L=1.0u
MN354    #177     #123     #128     0      MN1      W=    3.60u L=1.0u
MN353    #176     #123     #127     0      MN1      W=    3.60u L=1.0u
MP352    #191     #123     #127     1      MP1      W=    3.60u L=1.0u
MN351    #175     #123     #126     0      MN1      W=    3.60u L=1.0u
MN350    #174     #123     #125     0      MN1      W=    3.60u L=1.0u
MP349    #205     #123     #125     1      MP1      W=    3.60u L=1.0u
MN346    0      #173     #208     0      MN1      W=    3.60u L=1.0u
MP345    1      #88      #206     1      MP1      W=    3.60u L=1.0u
MP344    1      #165     #205     1      MP1      W=    3.60u L=1.0u
MP343    1      #103     #204     1      MP1      W=    3.60u L=1.0u
MP342    1      #172     #203     1      MP1      W=    3.60u L=1.0u
MP341    1      #101     #202     1      MP1      W=    3.60u L=1.0u
MP340    1      #171     #201     1      MP1      W=    3.60u L=1.0u
MP339    1      #99      #200     1      MP1      W=    3.60u L=1.0u
MP338    1      #170     #199     1      MP1      W=    3.60u L=1.0u
MP337    1      #97      #198     1      MP1      W=    3.60u L=1.0u
MP336    1      #169     #197     1      MP1      W=    3.60u L=1.0u
MP335    1      #95      #196     1      MP1      W=    3.60u L=1.0u
MP334    1      #168     #195     1      MP1      W=    3.60u L=1.0u
MP333    1      #93      #194     1      MP1      W=    3.60u L=1.0u
MP332    1      #167     #193     1      MP1      W=    3.60u L=1.0u
MP331    1      #91      #192     1      MP1      W=    3.60u L=1.0u
MP330    1      #166     #191     1      MP1      W=    3.60u L=1.0u
MP329    1      #89      #190     1      MP1      W=    3.60u L=1.0u
MN328    0      #164     #189     0      MN1      W=    3.60u L=1.0u
MN327    0      #102     #188     0      MN1      W=    3.60u L=1.0u
MN326    0      #163     #187     0      MN1      W=    3.60u L=1.0u
MN325    0      #100     #186     0      MN1      W=    3.60u L=1.0u
MN324    0      #162     #185     0      MN1      W=    3.60u L=1.0u
MN323    0      #98      #184     0      MN1      W=    3.60u L=1.0u
MN322    0      #161     #183     0      MN1      W=    3.60u L=1.0u
MN321    0      #96      #182     0      MN1      W=    3.60u L=1.0u
MN320    0      #160     #181     0      MN1      W=    3.60u L=1.0u
MN319    0      #94      #180     0      MN1      W=    3.60u L=1.0u
MN318    0      #159     #179     0      MN1      W=    3.60u L=1.0u
MN317    0      #92      #178     0      MN1      W=    3.60u L=1.0u
MN316    0      #158     #177     0      MN1      W=    3.60u L=1.0u
MN315    0      #90      #176     0      MN1      W=    3.60u L=1.0u
MN314    0      #157     #175     0      MN1      W=    3.60u L=1.0u
MN313    0      #104     #174     0      MN1      W=    3.60u L=1.0u
MN312    #87      #105     0      0      MN1      W=   14.40u L=1.0u
MP311    #87      #105     1      1      MP1      W=   43.20u L=1.0u
MP310    #54      #124     1      1      MP1      W=   10.80u L=1.0u
MP309    #141     #125     1      1      MP1      W=   10.80u L=1.0u
MN308    #54      #124     0      0      MN1      W=   10.80u L=1.0u
MP307    #156     #140     1      1      MP1      W=   10.80u L=1.0u
MP306    #155     #139     1      1      MP1      W=   10.80u L=1.0u
MP305    #154     #138     1      1      MP1      W=   10.80u L=1.0u
MP304    #153     #137     1      1      MP1      W=   10.80u L=1.0u
MP303    #152     #136     1      1      MP1      W=   10.80u L=1.0u
MP302    #151     #135     1      1      MP1      W=   10.80u L=1.0u
MP301    #150     #134     1      1      MP1      W=   10.80u L=1.0u
MP300    #149     #133     1      1      MP1      W=   10.80u L=1.0u
MP299    #148     #132     1      1      MP1      W=   10.80u L=1.0u
MP298    #147     #131     1      1      MP1      W=   10.80u L=1.0u
MP297    #146     #130     1      1      MP1      W=   10.80u L=1.0u
MP296    #145     #129     1      1      MP1      W=   10.80u L=1.0u
MP295    #144     #128     1      1      MP1      W=   10.80u L=1.0u
MP294    #143     #127     1      1      MP1      W=   10.80u L=1.0u
MP293    #142     #126     1      1      MP1      W=   10.80u L=1.0u
MN292    #156     #140     0      0      MN1      W=   10.80u L=1.0u
MN291    #155     #139     0      0      MN1      W=   10.80u L=1.0u
MN290    #154     #138     0      0      MN1      W=   10.80u L=1.0u
MN289    #153     #137     0      0      MN1      W=   10.80u L=1.0u
MN288    #152     #136     0      0      MN1      W=   10.80u L=1.0u
MN287    #151     #135     0      0      MN1      W=   10.80u L=1.0u
MN286    #150     #134     0      0      MN1      W=   10.80u L=1.0u
MN285    #149     #133     0      0      MN1      W=   10.80u L=1.0u
MN284    #148     #132     0      0      MN1      W=   10.80u L=1.0u
MN283    #147     #131     0      0      MN1      W=   10.80u L=1.0u
MN282    #146     #130     0      0      MN1      W=   10.80u L=1.0u
MN281    #145     #129     0      0      MN1      W=   10.80u L=1.0u
MN280    #144     #128     0      0      MN1      W=   10.80u L=1.0u
MN279    #143     #127     0      0      MN1      W=   10.80u L=1.0u
MN278    #142     #126     0      0      MN1      W=   10.80u L=1.0u
MN277    #141     #125     0      0      MN1      W=   10.80u L=1.0u
MP238    #85      #87      1      1      MP1      W=    3.60u L=1.0u
MP237    #69      #87      1      1      MP1      W=    3.60u L=1.0u
MP236    #68      #87      1      1      MP1      W=    3.60u L=1.0u
MP235    #67      #87      1      1      MP1      W=    3.60u L=1.0u
MP234    #66      #87      1      1      MP1      W=    3.60u L=1.0u
MP233    #65      #87      1      1      MP1      W=    3.60u L=1.0u
MP232    #64      #87      1      1      MP1      W=    3.60u L=1.0u
MP231    #63      #87      1      1      MP1      W=    3.60u L=1.0u
MP230    #62      #87      1      1      MP1      W=    3.60u L=1.0u
MP229    #61      #87      1      1      MP1      W=    3.60u L=1.0u
MP228    #60      #87      1      1      MP1      W=    3.60u L=1.0u
MP227    #59      #87      1      1      MP1      W=    3.60u L=1.0u
MP226    #58      #87      1      1      MP1      W=    3.60u L=1.0u
MP225    #57      #87      1      1      MP1      W=    3.60u L=1.0u
MP224    #56      #87      1      1      MP1      W=    3.60u L=1.0u
MP223    #55      #87      1      1      MP1      W=    3.60u L=1.0u
MP221    #104     #53      1      1      MP1      W=    3.60u L=1.0u
MN220    #122     #53      0      0      MN1      W=    3.60u L=1.0u
MN219    #121     #53      0      0      MN1      W=    3.60u L=1.0u
MN218    #120     #53      0      0      MN1      W=    3.60u L=1.0u
MN217    #119     #53      0      0      MN1      W=    3.60u L=1.0u
MN216    #118     #53      0      0      MN1      W=    3.60u L=1.0u
MN215    #117     #53      0      0      MN1      W=    3.60u L=1.0u
MN214    #116     #53      0      0      MN1      W=    3.60u L=1.0u
MN213    #115     #53      0      0      MN1      W=    3.60u L=1.0u
MN212    #114     #53      0      0      MN1      W=    3.60u L=1.0u
MN211    #113     #53      0      0      MN1      W=    3.60u L=1.0u
MN210    #112     #53      0      0      MN1      W=    3.60u L=1.0u
MN209    #111     #53      0      0      MN1      W=    3.60u L=1.0u
MN208    #110     #53      0      0      MN1      W=    3.60u L=1.0u
MN207    #109     #53      0      0      MN1      W=    3.60u L=1.0u
MN206    #108     #53      0      0      MN1      W=    3.60u L=1.0u
MN205    #107     #53      0      0      MN1      W=    3.60u L=1.0u
MN204    #106     #53      0      0      MN1      W=    3.60u L=1.0u
MP202    #88      #52      #85      1      MP1      W=    3.60u L=1.0u
MP201    #103     #52      #69      1      MP1      W=    3.60u L=1.0u
MP200    #102     #51      #68      1      MP1      W=    3.60u L=1.0u
MP199    #101     #50      #67      1      MP1      W=    3.60u L=1.0u
MP198    #100     #49      #66      1      MP1      W=    3.60u L=1.0u
MP197    #99      #48      #65      1      MP1      W=    3.60u L=1.0u
MP196    #98      #47      #64      1      MP1      W=    3.60u L=1.0u
MP195    #97      #46      #63      1      MP1      W=    3.60u L=1.0u
MP194    #96      #45      #62      1      MP1      W=    3.60u L=1.0u
MP193    #95      #44      #61      1      MP1      W=    3.60u L=1.0u
MP192    #94      #43      #60      1      MP1      W=    3.60u L=1.0u
MP191    #93      #42      #59      1      MP1      W=    3.60u L=1.0u
MP190    #92      #41      #58      1      MP1      W=    3.60u L=1.0u
MP189    #91      #40      #57      1      MP1      W=    3.60u L=1.0u
MP188    #90      #39      #56      1      MP1      W=    3.60u L=1.0u
MP187    #89      #38      #55      1      MP1      W=    3.60u L=1.0u
MN186    #103     #52      #122     0      MN1      W=    3.60u L=1.0u
MN185    #102     #51      #121     0      MN1      W=    3.60u L=1.0u
MN184    #101     #50      #120     0      MN1      W=    3.60u L=1.0u
MN183    #100     #49      #119     0      MN1      W=    3.60u L=1.0u
MN182    #99      #48      #118     0      MN1      W=    3.60u L=1.0u
MN181    #98      #47      #117     0      MN1      W=    3.60u L=1.0u
MN180    #97      #46      #116     0      MN1      W=    3.60u L=1.0u
MN179    #96      #45      #115     0      MN1      W=    3.60u L=1.0u
MN178    #95      #44      #114     0      MN1      W=    3.60u L=1.0u
MN177    #94      #43      #113     0      MN1      W=    3.60u L=1.0u
MN176    #93      #42      #112     0      MN1      W=    3.60u L=1.0u
MN175    #92      #41      #111     0      MN1      W=    3.60u L=1.0u
MN174    #91      #40      #110     0      MN1      W=    3.60u L=1.0u
MN173    #90      #39      #109     0      MN1      W=    3.60u L=1.0u
MN172    #89      #38      #108     0      MN1      W=    3.60u L=1.0u
MN171    #104     #37      #107     0      MN1      W=    3.60u L=1.0u
MP170    1      #37      #104     1      MP1      W=    3.60u L=1.0u
MN169    #53      #36      0      0      MN1      W=   14.40u L=1.0u
MN168    #88      #52      #106     0      MN1      W=    3.60u L=1.0u
MP167    #53      #36      1      1      MP1      W=   43.20u L=1.0u
MP166    #85      #53      #88      1      MP1      W=    3.60u L=1.0u
MP165    #69      #53      #103     1      MP1      W=    3.60u L=1.0u
MP164    #68      #53      #102     1      MP1      W=    3.60u L=1.0u
MP163    #67      #53      #101     1      MP1      W=    3.60u L=1.0u
MP162    #66      #53      #100     1      MP1      W=    3.60u L=1.0u
MP161    #65      #53      #99      1      MP1      W=    3.60u L=1.0u
MP160    #64      #53      #98      1      MP1      W=    3.60u L=1.0u
MP159    #63      #53      #97      1      MP1      W=    3.60u L=1.0u
MP158    #62      #53      #96      1      MP1      W=    3.60u L=1.0u
MP157    #61      #53      #95      1      MP1      W=    3.60u L=1.0u
MP156    #60      #53      #94      1      MP1      W=    3.60u L=1.0u
MP155    #59      #53      #93      1      MP1      W=    3.60u L=1.0u
MP154    #58      #53      #92      1      MP1      W=    3.60u L=1.0u
MP153    #57      #53      #91      1      MP1      W=    3.60u L=1.0u
MP152    #56      #53      #90      1      MP1      W=    3.60u L=1.0u
MP151    #55      #53      #89      1      MP1      W=    3.60u L=1.0u
MN150    #84      #87      #103     0      MN1      W=    3.60u L=1.0u
MN149    #83      #87      #102     0      MN1      W=    3.60u L=1.0u
MN148    #82      #87      #101     0      MN1      W=    3.60u L=1.0u
MN147    #81      #87      #100     0      MN1      W=    3.60u L=1.0u
MN146    #80      #87      #99      0      MN1      W=    3.60u L=1.0u
MN145    #79      #87      #98      0      MN1      W=    3.60u L=1.0u
MN144    #78      #87      #97      0      MN1      W=    3.60u L=1.0u
MN143    #77      #87      #96      0      MN1      W=    3.60u L=1.0u
MN142    #76      #87      #95      0      MN1      W=    3.60u L=1.0u
MN141    #75      #87      #94      0      MN1      W=    3.60u L=1.0u
MN140    #74      #87      #93      0      MN1      W=    3.60u L=1.0u
MN139    #73      #87      #92      0      MN1      W=    3.60u L=1.0u
MN138    #72      #87      #91      0      MN1      W=    3.60u L=1.0u
MN137    #71      #87      #90      0      MN1      W=    3.60u L=1.0u
MN136    #70      #87      #89      0      MN1      W=    3.60u L=1.0u
MN134    #86      #87      #88      0      MN1      W=    3.60u L=1.0u
MN132    0      #52      #86      0      MN1      W=    3.60u L=1.0u
MN131    0      #51      #84      0      MN1      W=    3.60u L=1.0u
MN130    0      #50      #83      0      MN1      W=    3.60u L=1.0u
MN129    0      #49      #82      0      MN1      W=    3.60u L=1.0u
MN128    0      #48      #81      0      MN1      W=    3.60u L=1.0u
MN127    0      #47      #80      0      MN1      W=    3.60u L=1.0u
MN126    0      #46      #79      0      MN1      W=    3.60u L=1.0u
MN125    0      #45      #78      0      MN1      W=    3.60u L=1.0u
MN124    0      #44      #77      0      MN1      W=    3.60u L=1.0u
MN123    0      #43      #76      0      MN1      W=    3.60u L=1.0u
MN122    0      #42      #75      0      MN1      W=    3.60u L=1.0u
MN121    0      #41      #74      0      MN1      W=    3.60u L=1.0u
MN120    0      #40      #73      0      MN1      W=    3.60u L=1.0u
MN119    0      #39      #72      0      MN1      W=    3.60u L=1.0u
MN118    0      #38      #71      0      MN1      W=    3.60u L=1.0u
MN117    0      #37      #70      0      MN1      W=    3.60u L=1.0u
MP116    1      #52      #85      1      MP1      W=    3.60u L=1.0u
MP115    1      #51      #69      1      MP1      W=    3.60u L=1.0u
MP114    1      #50      #68      1      MP1      W=    3.60u L=1.0u
MP113    1      #49      #67      1      MP1      W=    3.60u L=1.0u
MP112    1      #48      #66      1      MP1      W=    3.60u L=1.0u
MP111    1      #47      #65      1      MP1      W=    3.60u L=1.0u
MP110    1      #46      #64      1      MP1      W=    3.60u L=1.0u
MP109    1      #45      #63      1      MP1      W=    3.60u L=1.0u
MP108    1      #44      #62      1      MP1      W=    3.60u L=1.0u
MP107    1      #43      #61      1      MP1      W=    3.60u L=1.0u
MP106    1      #42      #60      1      MP1      W=    3.60u L=1.0u
MP105    1      #41      #59      1      MP1      W=    3.60u L=1.0u
MP104    1      #40      #58      1      MP1      W=    3.60u L=1.0u
MP103    1      #39      #57      1      MP1      W=    3.60u L=1.0u
MP102    1      #38      #56      1      MP1      W=    3.60u L=1.0u
MP101    1      #37      #55      1      MP1      W=    3.60u L=1.0u
MP98     #37      #18      1      1      MP1      W=   10.80u L=1.0u
MP97     #52      #17      1      1      MP1      W=   10.80u L=1.0u
MP96     #51      #16      1      1      MP1      W=   10.80u L=1.0u
MP95     #50      #15      1      1      MP1      W=   10.80u L=1.0u
MP94     #49      #14      1      1      MP1      W=   10.80u L=1.0u
MP93     #48      #13      1      1      MP1      W=   10.80u L=1.0u
MP92     #47      #12      1      1      MP1      W=   10.80u L=1.0u
MP91     #46      #11      1      1      MP1      W=   10.80u L=1.0u
MP90     #45      #10      1      1      MP1      W=   10.80u L=1.0u
MP89     #44      #9       1      1      MP1      W=   10.80u L=1.0u
MP88     #43      #8       1      1      MP1      W=   10.80u L=1.0u
MP87     #42      #7       1      1      MP1      W=   10.80u L=1.0u
MP86     #41      #6       1      1      MP1      W=   10.80u L=1.0u
MP85     #40      #5       1      1      MP1      W=   10.80u L=1.0u
MP84     #39      #4       1      1      MP1      W=   10.80u L=1.0u
MP83     #38      #3       1      1      MP1      W=   10.80u L=1.0u
MN82     #52      #17      0      0      MN1      W=   10.80u L=1.0u
MN81     #51      #16      0      0      MN1      W=   10.80u L=1.0u
MN80     #50      #15      0      0      MN1      W=   10.80u L=1.0u
MN79     #49      #14      0      0      MN1      W=   10.80u L=1.0u
MN78     #48      #13      0      0      MN1      W=   10.80u L=1.0u
MN77     #47      #12      0      0      MN1      W=   10.80u L=1.0u
MN76     #46      #11      0      0      MN1      W=   10.80u L=1.0u
MN75     #45      #10      0      0      MN1      W=   10.80u L=1.0u
MN74     #44      #9       0      0      MN1      W=   10.80u L=1.0u
MN73     #43      #8       0      0      MN1      W=   10.80u L=1.0u
MN72     #42      #7       0      0      MN1      W=   10.80u L=1.0u
MN71     #41      #6       0      0      MN1      W=   10.80u L=1.0u
MN70     #40      #5       0      0      MN1      W=   10.80u L=1.0u
MN69     #39      #4       0      0      MN1      W=   10.80u L=1.0u
MN68     #38      #3       0      0      MN1      W=   10.80u L=1.0u
MN67     #37      #18      0      0      MN1      W=   10.80u L=1.0u
MP32     #18      Y0       1      1      MP1      W=    5.40u L=1.0u
MN31     #17      Y15      0      0      MN1      W=    5.40u L=1.0u
MN30     #16      Y14      0      0      MN1      W=    5.40u L=1.0u
MN29     #15      Y13      0      0      MN1      W=    5.40u L=1.0u
MN28     #14      Y12      0      0      MN1      W=    5.40u L=1.0u
MN27     #13      Y11      0      0      MN1      W=    5.40u L=1.0u
MN26     #12      Y10      0      0      MN1      W=    5.40u L=1.0u
MN25     #11      Y9       0      0      MN1      W=    5.40u L=1.0u
MN24     #10      Y8       0      0      MN1      W=    5.40u L=1.0u
MN23     #9       Y7       0      0      MN1      W=    5.40u L=1.0u
MN22     #8       Y6       0      0      MN1      W=    5.40u L=1.0u
MN21     #7       Y5       0      0      MN1      W=    5.40u L=1.0u
MN20     #6       Y4       0      0      MN1      W=    5.40u L=1.0u
MN19     #5       Y3       0      0      MN1      W=    5.40u L=1.0u
MN18     #4       Y2       0      0      MN1      W=    5.40u L=1.0u
MN17     #3       Y1       0      0      MN1      W=    5.40u L=1.0u
MN16     #18      Y0       0      0      MN1      W=    5.40u L=1.0u
MP15     #17      Y15      1      1      MP1      W=    5.40u L=1.0u
MP14     #16      Y14      1      1      MP1      W=    5.40u L=1.0u
MP13     #15      Y13      1      1      MP1      W=    5.40u L=1.0u
MP12     #14      Y12      1      1      MP1      W=    5.40u L=1.0u
MP11     #13      Y11      1      1      MP1      W=    5.40u L=1.0u
MP10     #12      Y10      1      1      MP1      W=    5.40u L=1.0u
MP9      #11      Y9       1      1      MP1      W=    5.40u L=1.0u
MP8      #10      Y8       1      1      MP1      W=    5.40u L=1.0u
MP7      #9       Y7       1      1      MP1      W=    5.40u L=1.0u
MP6      #8       Y6       1      1      MP1      W=    5.40u L=1.0u
MP5      #7       Y5       1      1      MP1      W=    5.40u L=1.0u
MP4      #6       Y4       1      1      MP1      W=    5.40u L=1.0u
MP3      #5       Y3       1      1      MP1      W=    5.40u L=1.0u
MP2      #4       Y2       1      1      MP1      W=    5.40u L=1.0u
MP1      #3       Y1       1      1      MP1      W=    5.40u L=1.0u
*
C1       Y1       0      2.997485e-14
C2       Y2       0      2.997785e-14
C3       Y3       0      2.997485e-14
C4       Y4       0      2.997785e-14
C5       Y5       0      2.997485e-14
C6       Y6       0      2.997785e-14
C7       Y7       0      2.997485e-14
C8       Y8       0      2.997785e-14
C9       Y9       0      2.997485e-14
C10      Y10      0      2.997785e-14
C11      Y11      0      2.997485e-14
C12      Y12      0      2.997785e-14
C13      Y13      0      2.997485e-14
C14      Y14      0      2.997785e-14
C15      Y15      0      2.989485e-14
C16      Y0       0      3.116485e-14
C17      #3       0      7.034749e-14
C18      #4       0      7.034349e-14
C19      #5       0      7.034749e-14
C20      #6       0      7.034349e-14
C21      #7       0      7.034749e-14
C22      #8       0      7.034349e-14
C23      #9       0      7.034749e-14
C24      #10      0      7.034349e-14
C25      #11      0      7.034749e-14
C26      #12      0      7.034349e-14
C27      #13      0      7.034749e-14
C28      #14      0      7.034349e-14
C29      #15      0      7.034749e-14
C30      #16      0      7.034349e-14
C31      #17      0      7.012049e-14
C32      #18      0      7.432149e-14
C33      #86      0      7.939823e-15
C34      #70      0      9.595039e-15
C35      #71      0      9.595039e-15
C36      #72      0      9.595039e-15
C37      #73      0      9.595039e-15
C38      #74      0      9.595039e-15
C39      #75      0      9.595039e-15
C40      #76      0      9.595039e-15
C41      #77      0      9.595039e-15
C42      #78      0      9.595039e-15
C43      #79      0      9.595039e-15
C44      #80      0      9.595039e-15
C45      #81      0      9.595039e-15
C46      #82      0      9.595039e-15
C47      #83      0      9.595039e-15
C48      #84      0      9.595039e-15
C49      #106     0      1.107113e-14
C50      #107     0      8.109823e-15
C51      #108     0      7.845823e-15
C52      #109     0      7.845823e-15
C53      #110     0      7.845823e-15
C54      #111     0      7.845823e-15
C55      #112     0      7.845823e-15
C56      #113     0      7.845823e-15
C57      #114     0      7.845823e-15
C58      #115     0      7.845823e-15
C59      #116     0      7.845823e-15
C60      #117     0      7.845823e-15
C61      #118     0      7.845823e-15
C62      #119     0      7.845823e-15
C63      #120     0      7.845823e-15
C64      #121     0      7.845823e-15
C65      #122     0      7.845823e-15
C66      #53      0      5.360999e-13
C67      #55      0      2.105203e-14
C68      #56      0      2.105203e-14
C69      #57      0      2.105203e-14
C70      #58      0      2.105203e-14
C71      #59      0      2.105203e-14
C72      #60      0      2.105203e-14
C73      #61      0      2.105203e-14
C74      #62      0      2.105203e-14
C75      #63      0      2.105203e-14
C76      #64      0      2.105203e-14
C77      #65      0      2.105203e-14
C78      #66      0      2.105203e-14
C79      #67      0      2.105203e-14
C80      #68      0      2.105203e-14
C81      #69      0      2.105203e-14
C82      #85      0      2.107403e-14
C83      #87      0      5.589593e-13
C84      #205     0      9.049788e-15
C85      #174     0      1.004801e-14
C86      #175     0      9.846013e-15
C87      #191     0      9.206129e-15
C88      #176     0      9.846013e-15
C89      #177     0      9.846013e-15
C90      #193     0      9.206129e-15
C91      #178     0      9.846013e-15
C92      #179     0      9.846013e-15
C93      #195     0      9.206129e-15
C94      #180     0      9.846013e-15
C95      #181     0      9.846013e-15
C96      #197     0      9.206129e-15
C97      #182     0      9.846013e-15
C98      #183     0      9.846013e-15
C99      #199     0      9.206129e-15
C100     #184     0      9.846013e-15
C101     #185     0      9.846013e-15
C102     #201     0      9.206129e-15
C103     #186     0      9.846013e-15
C104     #187     0      9.846013e-15
C105     #203     0      9.206129e-15
C106     #188     0      9.846013e-15
C107     #190     0      9.503470e-15
C108     #192     0      9.503470e-15
C109     #194     0      9.503470e-15
C110     #196     0      9.503470e-15
C111     #198     0      9.503470e-15
C112     #200     0      9.503470e-15
C113     #202     0      9.503470e-15
C114     #189     0      1.022804e-14
C115     #204     0      9.503470e-15
C116     #206     0      9.018447e-15
C117     #208     0      8.322861e-15
C118     #127     0      7.579403e-14
C119     #129     0      7.579403e-14
C120     #131     0      7.579403e-14
C121     #133     0      7.579403e-14
C122     #135     0      7.579403e-14
C123     #137     0      7.579403e-14
C124     #139     0      7.579403e-14
C125     #126     0      7.605505e-14
C126     #128     0      7.605505e-14
C127     #130     0      7.605505e-14
C128     #132     0      7.605505e-14
C129     #134     0      7.605505e-14
C130     #136     0      7.605505e-14
C131     #138     0      7.605505e-14
C132     #140     0      7.562503e-14
C133     #125     0      7.434910e-14
C134     #124     0      7.893603e-14
C135     #210     0      7.862823e-15
C136     #211     0      7.862823e-15
C137     #212     0      7.862823e-15
C138     #213     0      7.862823e-15
C139     #214     0      7.862823e-15
C140     #215     0      7.862823e-15
C141     #216     0      7.862823e-15
C142     #217     0      7.840823e-15
C143     #218     0      7.840823e-15
C144     #219     0      7.840823e-15
C145     #220     0      7.840823e-15
C146     #221     0      7.840823e-15
C147     #222     0      7.840823e-15
C148     #223     0      7.840823e-15
C149     #224     0      7.840823e-15
C150     #226     0      8.283096e-15
C151     #227     0      8.283096e-15
C152     #228     0      8.283096e-15
C153     #229     0      8.283096e-15
C154     #230     0      8.283096e-15
C155     #231     0      8.283096e-15
C156     #232     0      8.283096e-15
C157     #233     0      7.796823e-15
C158     #234     0      8.261096e-15
C159     #235     0      8.261096e-15
C160     #236     0      8.261096e-15
C161     #237     0      8.261096e-15
C162     #238     0      8.261096e-15
C163     #239     0      8.261096e-15
C164     #240     0      8.261096e-15
C165     #241     0      8.261096e-15
C166     #225     0      8.557777e-15
C167     #242     0      8.238095e-15
C168     #243     0      7.729823e-15
C169     #209     0      4.528742e-13
C170     #157     0      3.388527e-14
C171     #89      0      6.752094e-14
C172     #166     0      3.475127e-14
C173     #90      0      6.713094e-14
C174     #158     0      3.388527e-14
C175     #91      0      6.752094e-14
C176     #167     0      3.475127e-14
C177     #92      0      6.713094e-14
C178     #159     0      3.388527e-14
C179     #93      0      6.752094e-14
C180     #168     0      3.475127e-14
C181     #94      0      6.713094e-14
C182     #160     0      3.388527e-14
C183     #95      0      6.752094e-14
C184     #169     0      3.475127e-14
C185     #96      0      6.713094e-14
C186     #161     0      3.388527e-14
C187     #97      0      6.752094e-14
C188     #170     0      3.475127e-14
C189     #98      0      6.713094e-14
C190     #162     0      3.388527e-14
C191     #99      0      6.752094e-14
C192     #171     0      3.475127e-14
C193     #100     0      6.713094e-14
C194     #163     0      3.388527e-14
C195     #101     0      6.752094e-14
C196     #172     0      3.475127e-14
C197     #102     0      6.713094e-14
C198     #165     0      3.346627e-14
C199     #104     0      6.004554e-14
C200     #164     0      3.376627e-14
C201     #103     0      6.740694e-14
C202     #173     0      3.414827e-14
C203     #88      0      7.079779e-14
C204     #280     0      2.752763e-14
C205     #281     0      1.470808e-14
C206     #279     0      1.863045e-14
C207     #245     0      1.869816e-14
C208     #156     0      8.132302e-14
C209     #283     0      1.042716e-14
C210     #285     0      1.222359e-14
C211     #105     0      2.164202e-13
C212     #287     0      1.232059e-14
C213     #247     0      4.493020e-14
C214     #305     0      1.120425e-14
C215     #249     0      5.261559e-14
C216     #250     0      5.231759e-14
C217     #251     0      5.261559e-14
C218     #252     0      5.231759e-14
C219     #253     0      5.261559e-14
C220     #254     0      5.231759e-14
C221     #255     0      5.261559e-14
C222     #256     0      5.231759e-14
C223     #257     0      5.261559e-14
C224     #258     0      5.231759e-14
C225     #259     0      5.261559e-14
C226     #260     0      5.231759e-14
C227     #261     0      5.261559e-14
C228     #262     0      5.231759e-14
C229     #263     0      5.261559e-14
C230     #264     0      4.925286e-14
C231     #265     0      4.954986e-14
C232     #266     0      4.925286e-14
C233     #267     0      4.954986e-14
C234     #268     0      4.925286e-14
C235     #269     0      4.954986e-14
C236     #270     0      4.925286e-14
C237     #271     0      4.954986e-14
C238     #272     0      4.925286e-14
C239     #273     0      4.954986e-14
C240     #274     0      4.925286e-14
C241     #275     0      4.954986e-14
C242     #276     0      4.925286e-14
C243     #277     0      4.954986e-14
C244     #278     0      4.925286e-14
C245     #307     0      1.455661e-14
C246     #304     0      4.465194e-14
C247     X15      0      1.574753e-13
C248     #288     0      7.375704e-14
C249     #324     0      1.455608e-14
C250     #246     0      8.458875e-14
C251     #306     0      1.922745e-14
C252     #284     0      4.953397e-14
C253     #326     0      1.152330e-14
C254     #327     0      1.138806e-14
C255     #328     0      1.187606e-14
C256     #329     0      1.138806e-14
C257     #330     0      1.187606e-14
C258     #331     0      1.138806e-14
C259     #332     0      1.187606e-14
C260     #333     0      1.138806e-14
C261     #334     0      1.187606e-14
C262     #335     0      1.138806e-14
C263     #336     0      1.187606e-14
C264     #337     0      1.138806e-14
C265     #338     0      1.187606e-14
C266     #339     0      1.138806e-14
C267     #340     0      1.187606e-14
C268     #342     0      1.257959e-14
C269     #343     0      1.204059e-14
C270     #344     0      1.257959e-14
C271     #345     0      1.204059e-14
C272     #346     0      1.257959e-14
C273     #347     0      1.204059e-14
C274     #348     0      1.257959e-14
C275     #349     0      1.204059e-14
C276     #350     0      1.257959e-14
C277     #351     0      1.204059e-14
C278     #352     0      1.257959e-14
C279     #353     0      1.204059e-14
C280     #354     0      1.257959e-14
C281     #355     0      1.204059e-14
C282     #341     0      1.213392e-14
C283     #357     0      2.767863e-14
C284     #36      0      2.425915e-13
C285     Z31      0      7.148436e-14
C286     #325     0      1.869816e-14
C287     X14      0      1.581687e-13
C288     #393     0      3.773348e-15
C289     #394     0      1.063814e-14
C290     #391     0      7.188703e-14
C291     #361     0      2.105623e-14
C292     #363     0      2.109423e-14
C293     #365     0      2.109423e-14
C294     #367     0      2.109423e-14
C295     #369     0      2.109423e-14
C296     #371     0      2.109423e-14
C297     #373     0      2.109423e-14
C298     #375     0      2.109423e-14
C299     #376     0      2.007503e-14
C300     #377     0      2.007503e-14
C301     #378     0      2.007503e-14
C302     #379     0      2.007503e-14
C303     #380     0      2.007503e-14
C304     #381     0      2.007503e-14
C305     #382     0      2.007503e-14
C306     #383     0      2.007503e-14
C307     #384     0      2.007503e-14
C308     #385     0      2.007503e-14
C309     #386     0      2.007503e-14
C310     #387     0      2.007503e-14
C311     #388     0      2.007503e-14
C312     #244     0      1.075261e-13
C313     #389     0      2.007503e-14
C314     #390     0      2.007503e-14
C315     #362     0      2.113223e-14
C316     #364     0      2.113223e-14
C317     #366     0      2.113223e-14
C318     #368     0      2.113223e-14
C319     #370     0      2.113223e-14
C320     #372     0      2.113223e-14
C321     #374     0      2.113223e-14
C322     #358     0      2.917067e-14
C323     #360     0      2.471003e-14
C324     #359     0      2.694664e-14
C325     #308     0      9.687889e-14
C326     #309     0      9.687489e-14
C327     #310     0      9.669888e-14
C328     #311     0      9.672788e-14
C329     #312     0      9.669888e-14
C330     #313     0      9.672788e-14
C331     #314     0      9.669888e-14
C332     #315     0      9.672788e-14
C333     #316     0      9.669888e-14
C334     #317     0      9.672788e-14
C335     #318     0      9.669888e-14
C336     #319     0      9.672788e-14
C337     #320     0      9.669888e-14
C338     #321     0      9.672788e-14
C339     #141     0      8.600769e-14
C340     Z30      0      3.714827e-14
C341     #411     0      1.056918e-14
C342     #412     0      1.048203e-14
C343     #413     0      1.048203e-14
C344     #414     0      1.048203e-14
C345     #415     0      1.048203e-14
C346     #416     0      1.048203e-14
C347     #417     0      1.048203e-14
C348     #418     0      1.048203e-14
C349     #419     0      1.048203e-14
C350     #420     0      1.048203e-14
C351     #421     0      1.048203e-14
C352     #422     0      1.048203e-14
C353     #423     0      1.048203e-14
C354     #424     0      1.048203e-14
C355     #425     0      1.048203e-14
C356     #392     0      7.901629e-14
C357     #441     0      1.132230e-14
C358     #142     0      1.679070e-13
C359     #426     0      9.993449e-15
C360     #143     0      1.672439e-13
C361     #427     0      9.993449e-15
C362     #144     0      1.671399e-13
C363     #428     0      9.993449e-15
C364     #145     0      1.672439e-13
C365     #429     0      9.993449e-15
C366     #146     0      1.671399e-13
C367     #430     0      9.993449e-15
C368     #147     0      1.672439e-13
C369     #431     0      9.993449e-15
C370     #148     0      1.671399e-13
C371     #432     0      9.993449e-15
C372     #149     0      1.672439e-13
C373     #433     0      9.993449e-15
C374     #150     0      1.671399e-13
C375     #434     0      9.993449e-15
C376     #151     0      1.672439e-13
C377     #435     0      9.993449e-15
C378     #152     0      1.671399e-13
C379     #436     0      9.993449e-15
C380     #153     0      1.672439e-13
C381     #437     0      9.993449e-15
C382     #154     0      1.671399e-13
C383     #438     0      9.993449e-15
C384     #155     0      1.672439e-13
C385     #439     0      9.993449e-15
C386     #123     0      7.116347e-13
C387     #440     0      1.015745e-14
C388     #286     0      1.378873e-13
C389     #442     0      1.227659e-14
C390     #459     0      1.132230e-14
C391     #444     0      1.153895e-14
C392     #446     0      1.153895e-14
C393     #448     0      1.153895e-14
C394     #450     0      1.153895e-14
C395     #452     0      1.153895e-14
C396     #454     0      1.153895e-14
C397     #456     0      1.153895e-14
C398     #460     0      1.213392e-14
C399     #462     0      1.213392e-14
C400     #464     0      1.213392e-14
C401     #466     0      1.213392e-14
C402     #468     0      1.213392e-14
C403     #470     0      1.213392e-14
C404     #472     0      1.213392e-14
C405     #54      0      1.563901e-13
C406     #475     0      1.289259e-14
C407     #461     0      1.306726e-14
C408     #463     0      1.306726e-14
C409     #465     0      1.306726e-14
C410     #467     0      1.306726e-14
C411     #469     0      1.306726e-14
C412     #471     0      1.306726e-14
C413     #473     0      1.306726e-14
C414     #445     0      1.395308e-14
C415     #447     0      1.395308e-14
C416     #449     0      1.395308e-14
C417     #451     0      1.395308e-14
C418     #453     0      1.395308e-14
C419     #455     0      1.395308e-14
C420     #457     0      1.395308e-14
C421     #474     0      1.428060e-14
C422     #443     0      1.606544e-14
C423     #323     0      4.944033e-14
C424     #477     0      4.250638e-15
C425     #410     0      4.351619e-14
C426     Z29      0      1.684745e-14
C427     #458     0      1.209989e-14
C428     #403     0      6.952578e-14
C429     #396     0      6.808735e-14
C430     #404     0      6.903778e-14
C431     #397     0      6.808735e-14
C432     #405     0      6.903778e-14
C433     #398     0      6.808735e-14
C434     #406     0      6.903778e-14
C435     #399     0      6.808735e-14
C436     #407     0      6.903778e-14
C437     #400     0      6.808735e-14
C438     #408     0      6.903778e-14
C439     #401     0      6.808735e-14
C440     #409     0      6.903778e-14
C441     #402     0      6.808735e-14
C442     #395     0      6.505478e-14
C443     #497     0      1.143919e-14
C444     #512     0      9.595039e-15
C445     #513     0      1.106019e-14
C446     #514     0      1.106019e-14
C447     #515     0      1.106019e-14
C448     #516     0      1.106019e-14
C449     #517     0      1.106019e-14
C450     #518     0      1.106019e-14
C451     #519     0      1.106019e-14
C452     #520     0      1.106019e-14
C453     #521     0      1.106019e-14
C454     #522     0      1.106019e-14
C455     #523     0      1.106019e-14
C456     #524     0      1.106019e-14
C457     #525     0      1.106019e-14
C458     #526     0      1.106019e-14
C459     #545     0      8.235861e-15
C460     #546     0      7.845823e-15
C461     #547     0      7.845823e-15
C462     #548     0      7.845823e-15
C463     #549     0      7.845823e-15
C464     #550     0      7.845823e-15
C465     #551     0      7.845823e-15
C466     #552     0      7.845823e-15
C467     #553     0      7.845823e-15
C468     #554     0      7.845823e-15
C469     #555     0      7.845823e-15
C470     #556     0      7.845823e-15
C471     #557     0      7.845823e-15
C472     #558     0      7.845823e-15
C473     #559     0      7.845823e-15
C474     #560     0      7.845823e-15
C475     #561     0      7.845823e-15
C476     #493     0      5.502429e-13
C477     #498     0      2.105203e-14
C478     #499     0      2.105203e-14
C479     #500     0      2.105203e-14
C480     #501     0      2.105203e-14
C481     #502     0      2.105203e-14
C482     #503     0      2.105203e-14
C483     #504     0      2.105203e-14
C484     #505     0      2.105203e-14
C485     #506     0      2.105203e-14
C486     #507     0      2.105203e-14
C487     #508     0      2.105203e-14
C488     #509     0      2.105203e-14
C489     #510     0      2.105203e-14
C490     #511     0      2.105203e-14
C491     #495     0      2.381583e-14
C492     #496     0      2.405351e-14
C493     #289     0      2.044358e-13
C494     #290     0      2.052028e-13
C495     #291     0      2.037888e-13
C496     #292     0      2.042988e-13
C497     #293     0      2.037888e-13
C498     #294     0      2.042988e-13
C499     #295     0      2.037888e-13
C500     #296     0      2.042988e-13
C501     #297     0      2.037888e-13
C502     #298     0      2.042988e-13
C503     #299     0      2.037888e-13
C504     #300     0      2.042988e-13
C505     #301     0      2.037888e-13
C506     #302     0      2.046338e-13
C507     #303     0      2.051018e-13
C508     #529     0      5.728975e-13
C509     #632     0      8.728107e-15
C510     #600     0      9.504963e-15
C511     #603     0      9.504963e-15
C512     #605     0      9.504963e-15
C513     #607     0      9.504963e-15
C514     #609     0      9.504963e-15
C515     #611     0      9.504963e-15
C516     #613     0      9.504963e-15
C517     #615     0      9.504963e-15
C518     #601     0      9.745988e-15
C519     #617     0      9.503470e-15
C520     #618     0      9.503470e-15
C521     #602     0      9.745988e-15
C522     #619     0      9.503470e-15
C523     #620     0      9.503470e-15
C524     #604     0      9.745988e-15
C525     #621     0      9.503470e-15
C526     #622     0      9.503470e-15
C527     #606     0      9.745988e-15
C528     #623     0      9.503470e-15
C529     #624     0      9.503470e-15
C530     #608     0      9.745988e-15
C531     #625     0      9.503470e-15
C532     #626     0      9.503470e-15
C533     #610     0      9.745988e-15
C534     #627     0      9.503470e-15
C535     #628     0      9.503470e-15
C536     #612     0      9.745988e-15
C537     #629     0      9.503470e-15
C538     #630     0      9.503470e-15
C539     #614     0      9.745988e-15
C540     #631     0      9.503470e-15
C541     #633     0      8.884447e-15
C542     #616     0      9.745988e-15
C543     #579     0      7.362503e-14
C544     #563     0      7.464903e-14
C545     #564     0      7.593803e-14
C546     #565     0      7.817605e-14
C547     #566     0      7.655303e-14
C548     #567     0      7.817605e-14
C549     #568     0      7.655303e-14
C550     #569     0      7.817605e-14
C551     #570     0      7.655303e-14
C552     #571     0      7.817605e-14
C553     #572     0      7.655303e-14
C554     #573     0      7.817605e-14
C555     #574     0      7.655303e-14
C556     #575     0      7.817605e-14
C557     #576     0      7.655303e-14
C558     #577     0      8.012306e-14
C559     #578     0      7.740103e-14
C560     #635     0      7.785823e-15
C561     #636     0      7.807823e-15
C562     #637     0      7.807823e-15
C563     #638     0      7.807823e-15
C564     #639     0      7.807823e-15
C565     #640     0      7.807823e-15
C566     #641     0      7.807823e-15
C567     #642     0      7.807823e-15
C568     #643     0      7.807823e-15
C569     #644     0      7.807823e-15
C570     #645     0      7.807823e-15
C571     #646     0      7.807823e-15
C572     #647     0      7.807823e-15
C573     #648     0      7.807823e-15
C574     #649     0      7.807823e-15
C575     #650     0      7.807823e-15
C576     #651     0      7.807823e-15
C577     #652     0      8.294095e-15
C578     #653     0      8.316096e-15
C579     #654     0      8.316096e-15
C580     #655     0      8.316096e-15
C581     #656     0      8.316096e-15
C582     #657     0      8.316096e-15
C583     #658     0      8.316096e-15
C584     #659     0      8.316096e-15
C585     #660     0      8.316096e-15
C586     #661     0      8.316096e-15
C587     #662     0      8.316096e-15
C588     #663     0      8.316096e-15
C589     #664     0      8.316096e-15
C590     #665     0      8.316096e-15
C591     #666     0      8.316096e-15
C592     #667     0      8.316096e-15
C593     #668     0      8.316096e-15
C594     #634     0      4.797651e-13
C595     #590     0      3.475627e-14
C596     #544     0      6.122453e-14
C597     #583     0      3.414927e-14
C598     #530     0      6.932994e-14
C599     #592     0      3.404927e-14
C600     #531     0      6.666279e-14
C601     #584     0      3.394727e-14
C602     #532     0      6.585579e-14
C603     #593     0      3.404927e-14
C604     #533     0      6.658279e-14
C605     #585     0      3.394727e-14
C606     #534     0      6.585579e-14
C607     #594     0      3.404927e-14
C608     #535     0      6.658279e-14
C609     #586     0      3.394727e-14
C610     #536     0      6.585579e-14
C611     #595     0      3.404927e-14
C612     #537     0      6.658279e-14
C613     #587     0      3.394727e-14
C614     #538     0      6.585579e-14
C615     #596     0      3.404927e-14
C616     #539     0      6.658279e-14
C617     #588     0      3.394727e-14
C618     #540     0      6.585579e-14
C619     #597     0      3.404927e-14
C620     #541     0      6.658279e-14
C621     #589     0      3.394727e-14
C622     #542     0      6.585579e-14
C623     #598     0      3.404927e-14
C624     #543     0      6.658279e-14
C625     #591     0      3.483027e-14
C626     #527     0      6.842947e-14
C627     #599     0      3.500727e-14
C628     #528     0      7.420579e-14
C629     #704     0      2.752763e-14
C630     #707     0      5.125053e-15
C631     #706     0      1.425484e-14
C632     #670     0      1.869816e-14
C633     #492     0      1.016498e-13
C634     #709     0      1.042716e-14
C635     #562     0      2.168122e-13
C636     #728     0      1.269393e-14
C637     #729     0      1.120425e-14
C638     #731     0      1.729628e-14
C639     #674     0      5.261559e-14
C640     #675     0      5.231759e-14
C641     #676     0      5.261559e-14
C642     #677     0      5.231759e-14
C643     #678     0      5.261559e-14
C644     #679     0      5.231759e-14
C645     #680     0      5.261559e-14
C646     #681     0      5.231759e-14
C647     #682     0      5.261559e-14
C648     #683     0      5.231759e-14
C649     #684     0      5.261559e-14
C650     #685     0      5.231759e-14
C651     #686     0      5.261559e-14
C652     #687     0      5.231759e-14
C653     #688     0      5.261559e-14
C654     #689     0      4.925286e-14
C655     #690     0      4.954986e-14
C656     #691     0      4.925286e-14
C657     #692     0      4.954986e-14
C658     #693     0      4.925286e-14
C659     #694     0      4.954986e-14
C660     #695     0      4.925286e-14
C661     #696     0      4.954986e-14
C662     #697     0      4.925286e-14
C663     #698     0      4.954986e-14
C664     #699     0      4.925286e-14
C665     #700     0      4.954986e-14
C666     #701     0      4.925286e-14
C667     #702     0      4.954986e-14
C668     #703     0      4.925286e-14
C669     #730     0      4.459994e-14
C670     X13      0      2.401746e-13
C671     #711     0      7.375704e-14
C672     #746     0      1.485837e-14
C673     #749     0      1.152330e-14
C674     #750     0      1.138806e-14
C675     #751     0      1.187606e-14
C676     #752     0      1.138806e-14
C677     #753     0      1.187606e-14
C678     #754     0      1.138806e-14
C679     #755     0      1.187606e-14
C680     #756     0      1.138806e-14
C681     #757     0      1.187606e-14
C682     #758     0      1.138806e-14
C683     #759     0      1.187606e-14
C684     #760     0      1.138806e-14
C685     #761     0      1.187606e-14
C686     #762     0      1.138806e-14
C687     #763     0      1.187606e-14
C688     #765     0      1.257959e-14
C689     #766     0      1.204059e-14
C690     #767     0      1.257959e-14
C691     #768     0      1.204059e-14
C692     #769     0      1.257959e-14
C693     #770     0      1.204059e-14
C694     #771     0      1.257959e-14
C695     #772     0      1.204059e-14
C696     #773     0      1.257959e-14
C697     #774     0      1.204059e-14
C698     #775     0      1.257959e-14
C699     #776     0      1.204059e-14
C700     #777     0      1.257959e-14
C701     #778     0      1.204059e-14
C702     #764     0      1.213392e-14
C703     #673     0      5.659915e-14
C704     #672     0      1.125410e-13
C705     #705     0      4.871851e-14
C706     #780     0      2.767863e-14
C707     #494     0      2.409255e-13
C708     #748     0      1.869816e-14
C709     X12      0      1.581687e-13
C710     #816     0      3.773348e-15
C711     #815     0      1.063814e-14
C712     #814     0      7.188703e-14
C713     #782     0      2.105623e-14
C714     #784     0      2.109423e-14
C715     #786     0      2.109423e-14
C716     #788     0      2.109423e-14
C717     #790     0      2.109423e-14
C718     #792     0      2.109423e-14
C719     #794     0      2.109423e-14
C720     #796     0      2.109423e-14
C721     #797     0      2.007503e-14
C722     #798     0      2.007503e-14
C723     #799     0      2.007503e-14
C724     #800     0      2.007503e-14
C725     #801     0      2.007503e-14
C726     #802     0      2.007503e-14
C727     #803     0      2.007503e-14
C728     #804     0      2.007503e-14
C729     #805     0      2.007503e-14
C730     #806     0      2.007503e-14
C731     #807     0      2.007503e-14
C732     #808     0      2.007503e-14
C733     #809     0      2.007503e-14
C734     #669     0      1.067870e-13
C735     #810     0      2.007503e-14
C736     #811     0      2.007503e-14
C737     #783     0      2.113223e-14
C738     #785     0      2.113223e-14
C739     #787     0      2.113223e-14
C740     #789     0      2.113223e-14
C741     #791     0      2.113223e-14
C742     #793     0      2.113223e-14
C743     #795     0      2.113223e-14
C744     #812     0      2.812282e-14
C745     #322     0      1.249679e-13
C746     #813     0      2.613252e-14
C747     #732     0      9.687889e-14
C748     #733     0      9.687489e-14
C749     #734     0      9.669888e-14
C750     #735     0      9.672788e-14
C751     #736     0      9.669888e-14
C752     #737     0      9.672788e-14
C753     #738     0      9.669888e-14
C754     #739     0      9.672788e-14
C755     #740     0      9.669888e-14
C756     #741     0      9.672788e-14
C757     #742     0      9.669888e-14
C758     #743     0      9.672788e-14
C759     #744     0      9.669888e-14
C760     #745     0      9.672788e-14
C761     #581     0      8.572569e-14
C762     Z28      0      3.657970e-14
C763     #834     0      1.056918e-14
C764     #835     0      1.048203e-14
C765     #836     0      1.048203e-14
C766     #837     0      1.048203e-14
C767     #838     0      1.048203e-14
C768     #839     0      1.048203e-14
C769     #840     0      1.048203e-14
C770     #841     0      1.048203e-14
C771     #842     0      1.048203e-14
C772     #843     0      1.048203e-14
C773     #844     0      1.048203e-14
C774     #845     0      1.048203e-14
C775     #846     0      1.048203e-14
C776     #847     0      1.048203e-14
C777     #848     0      1.048203e-14
C778     #817     0      7.911415e-14
C779     #580     0      1.673100e-13
C780     #849     0      9.993449e-15
C781     #478     0      1.840860e-13
C782     #850     0      9.993449e-15
C783     #486     0      1.872908e-13
C784     #851     0      9.993449e-15
C785     #479     0      1.844157e-13
C786     #852     0      9.993449e-15
C787     #487     0      1.872238e-13
C788     #853     0      9.993449e-15
C789     #480     0      1.844157e-13
C790     #854     0      9.993449e-15
C791     #488     0      1.872238e-13
C792     #855     0      9.993449e-15
C793     #481     0      1.844157e-13
C794     #856     0      9.993449e-15
C795     #489     0      1.872238e-13
C796     #857     0      9.993449e-15
C797     #482     0      1.844157e-13
C798     #858     0      9.993449e-15
C799     #490     0      1.872238e-13
C800     #859     0      9.993449e-15
C801     #483     0      1.844157e-13
C802     #860     0      9.993449e-15
C803     #491     0      1.872238e-13
C804     #861     0      9.993449e-15
C805     #484     0      1.844157e-13
C806     #862     0      9.993449e-15
C807     #582     0      7.071188e-13
C808     #863     0      1.015745e-14
C809     #864     0      1.132230e-14
C810     #727     0      1.444799e-13
C811     #865     0      1.227659e-14
C812     #867     0      1.153895e-14
C813     #869     0      1.153895e-14
C814     #871     0      1.153895e-14
C815     #873     0      1.153895e-14
C816     #875     0      1.153895e-14
C817     #877     0      1.153895e-14
C818     #879     0      1.153895e-14
C819     #882     0      1.213392e-14
C820     #884     0      1.213392e-14
C821     #886     0      1.213392e-14
C822     #888     0      1.213392e-14
C823     #890     0      1.213392e-14
C824     #892     0      1.213392e-14
C825     #894     0      1.213392e-14
C826     #897     0      1.148218e-14
C827     #883     0      1.306726e-14
C828     #885     0      1.306726e-14
C829     #887     0      1.306726e-14
C830     #889     0      1.306726e-14
C831     #891     0      1.306726e-14
C832     #893     0      1.306726e-14
C833     #895     0      1.306726e-14
C834     #868     0      1.395308e-14
C835     #870     0      1.395308e-14
C836     #872     0      1.395308e-14
C837     #874     0      1.395308e-14
C838     #876     0      1.395308e-14
C839     #878     0      1.395308e-14
C840     #880     0      1.395308e-14
C841     #485     0      1.974727e-13
C842     #898     0      1.227659e-14
C843     #896     0      1.428060e-14
C844     #866     0      1.606544e-14
C845     #747     0      4.989034e-14
C846     #900     0      4.250638e-15
C847     #833     0      4.283319e-14
C848     Z27      0      1.684745e-14
C849     #881     0      1.192689e-14
C850     #781     0      3.734384e-14
C851     #826     0      6.952578e-14
C852     #819     0      6.808735e-14
C853     #827     0      6.903778e-14
C854     #820     0      6.808735e-14
C855     #828     0      6.903778e-14
C856     #821     0      6.808735e-14
C857     #829     0      6.903778e-14
C858     #822     0      6.808735e-14
C859     #830     0      6.903778e-14
C860     #823     0      6.808735e-14
C861     #831     0      6.903778e-14
C862     #824     0      6.808735e-14
C863     #832     0      6.903778e-14
C864     #825     0      6.808735e-14
C865     #818     0      6.505478e-14
C866     #919     0      1.143919e-14
C867     #935     0      9.595039e-15
C868     #936     0      1.106019e-14
C869     #937     0      1.106019e-14
C870     #938     0      1.106019e-14
C871     #939     0      1.106019e-14
C872     #940     0      1.106019e-14
C873     #941     0      1.106019e-14
C874     #942     0      1.106019e-14
C875     #943     0      1.106019e-14
C876     #944     0      1.106019e-14
C877     #945     0      1.106019e-14
C878     #946     0      1.106019e-14
C879     #947     0      1.106019e-14
C880     #948     0      1.106019e-14
C881     #949     0      1.106019e-14
C882     #968     0      8.235861e-15
C883     #918     0      2.148904e-14
C884     #920     0      2.148904e-14
C885     #969     0      7.845823e-15
C886     #970     0      7.845823e-15
C887     #971     0      7.845823e-15
C888     #972     0      7.845823e-15
C889     #973     0      7.845823e-15
C890     #974     0      7.845823e-15
C891     #975     0      7.845823e-15
C892     #976     0      7.845823e-15
C893     #977     0      7.845823e-15
C894     #978     0      7.845823e-15
C895     #979     0      7.845823e-15
C896     #980     0      7.845823e-15
C897     #981     0      7.845823e-15
C898     #982     0      7.845823e-15
C899     #983     0      7.845823e-15
C900     #984     0      7.845823e-15
C901     #917     0      5.502040e-13
C902     #921     0      2.105203e-14
C903     #922     0      2.105203e-14
C904     #923     0      2.105203e-14
C905     #924     0      2.105203e-14
C906     #925     0      2.105203e-14
C907     #926     0      2.105203e-14
C908     #927     0      2.105203e-14
C909     #928     0      2.105203e-14
C910     #929     0      2.105203e-14
C911     #930     0      2.105203e-14
C912     #931     0      2.105203e-14
C913     #932     0      2.105203e-14
C914     #933     0      2.105203e-14
C915     #934     0      2.105203e-14
C916     #712     0      2.044358e-13
C917     #713     0      2.052028e-13
C918     #714     0      2.037888e-13
C919     #715     0      2.042988e-13
C920     #716     0      2.037888e-13
C921     #717     0      2.042988e-13
C922     #718     0      2.037888e-13
C923     #719     0      2.042988e-13
C924     #720     0      2.037888e-13
C925     #721     0      2.042988e-13
C926     #722     0      2.037888e-13
C927     #723     0      2.042988e-13
C928     #724     0      2.037888e-13
C929     #725     0      2.045958e-13
C930     #726     0      2.049498e-13
C931     #952     0      5.727715e-13
C932     #1055    0      8.728107e-15
C933     #1023    0      9.504963e-15
C934     #1026    0      9.504963e-15
C935     #1028    0      9.504963e-15
C936     #1030    0      9.504963e-15
C937     #1032    0      9.504963e-15
C938     #1034    0      9.504963e-15
C939     #1036    0      9.504963e-15
C940     #1038    0      9.504963e-15
C941     #1024    0      9.745988e-15
C942     #1040    0      9.503470e-15
C943     #1041    0      9.503470e-15
C944     #1025    0      9.745988e-15
C945     #1042    0      9.503470e-15
C946     #1043    0      9.503470e-15
C947     #1027    0      9.745988e-15
C948     #1044    0      9.503470e-15
C949     #1045    0      9.503470e-15
C950     #1029    0      9.745988e-15
C951     #1046    0      9.503470e-15
C952     #1047    0      9.503470e-15
C953     #1031    0      9.745988e-15
C954     #1048    0      9.503470e-15
C955     #1049    0      9.503470e-15
C956     #1033    0      9.745988e-15
C957     #1050    0      9.503470e-15
C958     #1051    0      9.503470e-15
C959     #1035    0      9.745988e-15
C960     #1052    0      9.503470e-15
C961     #1053    0      9.503470e-15
C962     #1037    0      9.745988e-15
C963     #1054    0      9.503470e-15
C964     #1056    0      8.884447e-15
C965     #1039    0      9.745988e-15
C966     #1002    0      7.362503e-14
C967     #986     0      7.464903e-14
C968     #987     0      7.593803e-14
C969     #988     0      7.817605e-14
C970     #989     0      7.655303e-14
C971     #990     0      7.817605e-14
C972     #991     0      7.655303e-14
C973     #992     0      7.817605e-14
C974     #993     0      7.655303e-14
C975     #994     0      7.817605e-14
C976     #995     0      7.655303e-14
C977     #996     0      7.817605e-14
C978     #997     0      7.655303e-14
C979     #998     0      7.817605e-14
C980     #999     0      7.655303e-14
C981     #1000    0      7.902905e-14
C982     #1001    0      7.689703e-14
C983     #1058    0      7.785823e-15
C984     #1059    0      7.807823e-15
C985     #1060    0      7.807823e-15
C986     #1061    0      7.807823e-15
C987     #1062    0      7.807823e-15
C988     #1063    0      7.807823e-15
C989     #1064    0      7.807823e-15
C990     #1065    0      7.807823e-15
C991     #1066    0      7.807823e-15
C992     #1067    0      7.807823e-15
C993     #1068    0      7.807823e-15
C994     #1069    0      7.807823e-15
C995     #1070    0      7.807823e-15
C996     #1071    0      7.807823e-15
C997     #1072    0      7.807823e-15
C998     #1073    0      7.807823e-15
C999     #1074    0      7.807823e-15
C1000    #1075    0      8.294095e-15
C1001    #1076    0      8.316096e-15
C1002    #1077    0      8.316096e-15
C1003    #1078    0      8.316096e-15
C1004    #1079    0      8.316096e-15
C1005    #1080    0      8.316096e-15
C1006    #1081    0      8.316096e-15
C1007    #1082    0      8.316096e-15
C1008    #1083    0      8.316096e-15
C1009    #1084    0      8.316096e-15
C1010    #1085    0      8.316096e-15
C1011    #1086    0      8.316096e-15
C1012    #1087    0      8.316096e-15
C1013    #1088    0      8.316096e-15
C1014    #1089    0      8.316096e-15
C1015    #1090    0      8.316096e-15
C1016    #1091    0      8.316096e-15
C1017    #1057    0      4.792581e-13
C1018    #1014    0      3.475627e-14
C1019    #967     0      6.122453e-14
C1020    #1006    0      3.414927e-14
C1021    #953     0      6.932994e-14
C1022    #1015    0      3.404927e-14
C1023    #954     0      6.666279e-14
C1024    #1007    0      3.394727e-14
C1025    #955     0      6.585579e-14
C1026    #1016    0      3.404927e-14
C1027    #956     0      6.658279e-14
C1028    #1008    0      3.394727e-14
C1029    #957     0      6.585579e-14
C1030    #1017    0      3.404927e-14
C1031    #958     0      6.658279e-14
C1032    #1009    0      3.394727e-14
C1033    #959     0      6.585579e-14
C1034    #1018    0      3.404927e-14
C1035    #960     0      6.658279e-14
C1036    #1010    0      3.394727e-14
C1037    #961     0      6.585579e-14
C1038    #1019    0      3.404927e-14
C1039    #962     0      6.658279e-14
C1040    #1011    0      3.394727e-14
C1041    #963     0      6.585579e-14
C1042    #1020    0      3.404927e-14
C1043    #964     0      6.658279e-14
C1044    #1012    0      3.394727e-14
C1045    #965     0      6.585579e-14
C1046    #1021    0      3.404927e-14
C1047    #966     0      6.658279e-14
C1048    #1013    0      3.463027e-14
C1049    #951     0      6.751379e-14
C1050    #1022    0      3.471027e-14
C1051    #950     0      7.387979e-14
C1052    #1128    0      2.752763e-14
C1053    #1129    0      1.470808e-14
C1054    #1127    0      1.863045e-14
C1055    #1093    0      1.869816e-14
C1056    #915     0      1.023898e-13
C1057    #1131    0      1.042716e-14
C1058    #1133    0      1.222359e-14
C1059    #985     0      2.168122e-13
C1060    #1135    0      1.232059e-14
C1061    #1095    0      4.493020e-14
C1062    #1153    0      1.120425e-14
C1063    #1097    0      5.261559e-14
C1064    #1098    0      5.231759e-14
C1065    #1099    0      5.261559e-14
C1066    #1100    0      5.231759e-14
C1067    #1101    0      5.261559e-14
C1068    #1102    0      5.231759e-14
C1069    #1103    0      5.261559e-14
C1070    #1104    0      5.231759e-14
C1071    #1105    0      5.261559e-14
C1072    #1106    0      5.231759e-14
C1073    #1107    0      5.261559e-14
C1074    #1108    0      5.231759e-14
C1075    #1109    0      5.261559e-14
C1076    #1110    0      5.231759e-14
C1077    #1111    0      5.261559e-14
C1078    #1112    0      4.925286e-14
C1079    #1113    0      4.954986e-14
C1080    #1114    0      4.925286e-14
C1081    #1115    0      4.954986e-14
C1082    #1116    0      4.925286e-14
C1083    #1117    0      4.954986e-14
C1084    #1118    0      4.925286e-14
C1085    #1119    0      4.954986e-14
C1086    #1120    0      4.925286e-14
C1087    #1121    0      4.954986e-14
C1088    #1122    0      4.925286e-14
C1089    #1123    0      4.954986e-14
C1090    #1124    0      4.925286e-14
C1091    #1125    0      4.954986e-14
C1092    #1126    0      4.925286e-14
C1093    #1155    0      1.455661e-14
C1094    #1152    0      4.465194e-14
C1095    X11      0      2.401746e-13
C1096    #1136    0      7.375704e-14
C1097    #1172    0      1.455608e-14
C1098    #1094    0      8.458875e-14
C1099    #1154    0      1.922745e-14
C1100    #1132    0      4.953397e-14
C1101    #1174    0      1.152330e-14
C1102    #1175    0      1.138806e-14
C1103    #1176    0      1.187606e-14
C1104    #1177    0      1.138806e-14
C1105    #1178    0      1.187606e-14
C1106    #1179    0      1.138806e-14
C1107    #1180    0      1.187606e-14
C1108    #1181    0      1.138806e-14
C1109    #1182    0      1.187606e-14
C1110    #1183    0      1.138806e-14
C1111    #1184    0      1.187606e-14
C1112    #1185    0      1.138806e-14
C1113    #1186    0      1.187606e-14
C1114    #1187    0      1.138806e-14
C1115    #1188    0      1.187606e-14
C1116    #1190    0      1.257959e-14
C1117    #1191    0      1.204059e-14
C1118    #1192    0      1.257959e-14
C1119    #1193    0      1.204059e-14
C1120    #1194    0      1.257959e-14
C1121    #1195    0      1.204059e-14
C1122    #1196    0      1.257959e-14
C1123    #1197    0      1.204059e-14
C1124    #1198    0      1.257959e-14
C1125    #1199    0      1.204059e-14
C1126    #1200    0      1.257959e-14
C1127    #1201    0      1.204059e-14
C1128    #1202    0      1.257959e-14
C1129    #1203    0      1.204059e-14
C1130    #1189    0      1.213392e-14
C1131    #1205    0      2.767863e-14
C1132    #916     0      2.409255e-13
C1133    #710     0      1.054867e-13
C1134    #1173    0      1.869816e-14
C1135    X10      0      1.581687e-13
C1136    #1241    0      3.773348e-15
C1137    #1242    0      1.063814e-14
C1138    #1239    0      7.188703e-14
C1139    #1209    0      2.105623e-14
C1140    #1211    0      2.109423e-14
C1141    #1213    0      2.109423e-14
C1142    #1215    0      2.109423e-14
C1143    #1217    0      2.109423e-14
C1144    #1219    0      2.109423e-14
C1145    #1221    0      2.109423e-14
C1146    #1223    0      2.109423e-14
C1147    #1224    0      2.007503e-14
C1148    #1225    0      2.007503e-14
C1149    #1226    0      2.007503e-14
C1150    #1227    0      2.007503e-14
C1151    #1228    0      2.007503e-14
C1152    #1229    0      2.007503e-14
C1153    #1230    0      2.007503e-14
C1154    #1231    0      2.007503e-14
C1155    #1232    0      2.007503e-14
C1156    #1233    0      2.007503e-14
C1157    #1234    0      2.007503e-14
C1158    #1235    0      2.007503e-14
C1159    #1236    0      2.007503e-14
C1160    #1092    0      1.075261e-13
C1161    #1237    0      2.007503e-14
C1162    #1238    0      2.007503e-14
C1163    #1210    0      2.113223e-14
C1164    #1212    0      2.113223e-14
C1165    #1214    0      2.113223e-14
C1166    #1216    0      2.113223e-14
C1167    #1218    0      2.113223e-14
C1168    #1220    0      2.113223e-14
C1169    #1222    0      2.113223e-14
C1170    #1206    0      2.917067e-14
C1171    #1208    0      2.471003e-14
C1172    #1207    0      2.694664e-14
C1173    #1156    0      9.687889e-14
C1174    #1157    0      9.687489e-14
C1175    #1158    0      9.669888e-14
C1176    #1159    0      9.672788e-14
C1177    #1160    0      9.669888e-14
C1178    #1161    0      9.672788e-14
C1179    #1162    0      9.669888e-14
C1180    #1163    0      9.672788e-14
C1181    #1164    0      9.669888e-14
C1182    #1165    0      9.672788e-14
C1183    #1166    0      9.669888e-14
C1184    #1167    0      9.672788e-14
C1185    #1168    0      9.669888e-14
C1186    #1169    0      9.672788e-14
C1187    #1004    0      8.572569e-14
C1188    Z26      0      3.714827e-14
C1189    #1259    0      1.056918e-14
C1190    #1260    0      1.048203e-14
C1191    #1261    0      1.048203e-14
C1192    #1262    0      1.048203e-14
C1193    #1263    0      1.048203e-14
C1194    #1264    0      1.048203e-14
C1195    #1265    0      1.048203e-14
C1196    #1266    0      1.048203e-14
C1197    #1267    0      1.048203e-14
C1198    #1268    0      1.048203e-14
C1199    #1269    0      1.048203e-14
C1200    #1270    0      1.048203e-14
C1201    #1271    0      1.048203e-14
C1202    #1272    0      1.048203e-14
C1203    #1273    0      1.048203e-14
C1204    #1240    0      7.901629e-14
C1205    #1289    0      1.132230e-14
C1206    #1003    0      1.673100e-13
C1207    #1274    0      9.993449e-15
C1208    #901     0      1.840860e-13
C1209    #1275    0      9.993449e-15
C1210    #909     0      1.872908e-13
C1211    #1276    0      9.993449e-15
C1212    #902     0      1.844157e-13
C1213    #1277    0      9.993449e-15
C1214    #910     0      1.872238e-13
C1215    #1278    0      9.993449e-15
C1216    #903     0      1.844157e-13
C1217    #1279    0      9.993449e-15
C1218    #911     0      1.872238e-13
C1219    #1280    0      9.993449e-15
C1220    #904     0      1.844157e-13
C1221    #1281    0      9.993449e-15
C1222    #912     0      1.872238e-13
C1223    #1282    0      9.993449e-15
C1224    #905     0      1.844157e-13
C1225    #1283    0      9.993449e-15
C1226    #913     0      1.872238e-13
C1227    #1284    0      9.993449e-15
C1228    #906     0      1.844157e-13
C1229    #1285    0      9.993449e-15
C1230    #914     0      1.872238e-13
C1231    #1286    0      9.993449e-15
C1232    #907     0      1.844157e-13
C1233    #1287    0      9.993449e-15
C1234    #1005    0      7.070788e-13
C1235    #1288    0      1.015745e-14
C1236    #1134    0      1.378873e-13
C1237    #1290    0      1.227659e-14
C1238    #1307    0      1.132230e-14
C1239    #1292    0      1.153895e-14
C1240    #1294    0      1.153895e-14
C1241    #1296    0      1.153895e-14
C1242    #1298    0      1.153895e-14
C1243    #1300    0      1.153895e-14
C1244    #1302    0      1.153895e-14
C1245    #1304    0      1.153895e-14
C1246    #1308    0      1.213392e-14
C1247    #1310    0      1.213392e-14
C1248    #1312    0      1.213392e-14
C1249    #1314    0      1.213392e-14
C1250    #1316    0      1.213392e-14
C1251    #1318    0      1.213392e-14
C1252    #1320    0      1.213392e-14
C1253    #908     0      1.628715e-13
C1254    #1323    0      1.289259e-14
C1255    #1309    0      1.306726e-14
C1256    #1311    0      1.306726e-14
C1257    #1313    0      1.306726e-14
C1258    #1315    0      1.306726e-14
C1259    #1317    0      1.306726e-14
C1260    #1319    0      1.306726e-14
C1261    #1321    0      1.306726e-14
C1262    #1293    0      1.395308e-14
C1263    #1295    0      1.395308e-14
C1264    #1297    0      1.395308e-14
C1265    #1299    0      1.395308e-14
C1266    #1301    0      1.395308e-14
C1267    #1303    0      1.395308e-14
C1268    #1305    0      1.395308e-14
C1269    #1322    0      1.428060e-14
C1270    #1291    0      1.606544e-14
C1271    #1171    0      4.944033e-14
C1272    #1325    0      4.250638e-15
C1273    #1258    0      4.351619e-14
C1274    Z25      0      1.684745e-14
C1275    #1306    0      1.209989e-14
C1276    #1251    0      6.952578e-14
C1277    #1244    0      6.808735e-14
C1278    #1252    0      6.903778e-14
C1279    #1245    0      6.808735e-14
C1280    #1253    0      6.903778e-14
C1281    #1246    0      6.808735e-14
C1282    #1254    0      6.903778e-14
C1283    #1247    0      6.808735e-14
C1284    #1255    0      6.903778e-14
C1285    #1248    0      6.808735e-14
C1286    #1256    0      6.903778e-14
C1287    #1249    0      6.808735e-14
C1288    #1257    0      6.903778e-14
C1289    #1250    0      6.808735e-14
C1290    #1243    0      6.505478e-14
C1291    #1345    0      1.143919e-14
C1292    #1360    0      9.595039e-15
C1293    #1361    0      1.106019e-14
C1294    #1362    0      1.106019e-14
C1295    #1363    0      1.106019e-14
C1296    #1364    0      1.106019e-14
C1297    #1365    0      1.106019e-14
C1298    #1366    0      1.106019e-14
C1299    #1367    0      1.106019e-14
C1300    #1368    0      1.106019e-14
C1301    #1369    0      1.106019e-14
C1302    #1370    0      1.106019e-14
C1303    #1371    0      1.106019e-14
C1304    #1372    0      1.106019e-14
C1305    #1373    0      1.106019e-14
C1306    #1374    0      1.106019e-14
C1307    #1393    0      8.235861e-15
C1308    #1394    0      7.845823e-15
C1309    #1395    0      7.845823e-15
C1310    #1396    0      7.845823e-15
C1311    #1397    0      7.845823e-15
C1312    #1398    0      7.845823e-15
C1313    #1399    0      7.845823e-15
C1314    #1400    0      7.845823e-15
C1315    #1401    0      7.845823e-15
C1316    #1402    0      7.845823e-15
C1317    #1403    0      7.845823e-15
C1318    #1404    0      7.845823e-15
C1319    #1405    0      7.845823e-15
C1320    #1406    0      7.845823e-15
C1321    #1407    0      7.845823e-15
C1322    #1408    0      7.845823e-15
C1323    #1409    0      7.845823e-15
C1324    #1341    0      5.502429e-13
C1325    #1346    0      2.105203e-14
C1326    #1347    0      2.105203e-14
C1327    #1348    0      2.105203e-14
C1328    #1349    0      2.105203e-14
C1329    #1350    0      2.105203e-14
C1330    #1351    0      2.105203e-14
C1331    #1352    0      2.105203e-14
C1332    #1353    0      2.105203e-14
C1333    #1354    0      2.105203e-14
C1334    #1355    0      2.105203e-14
C1335    #1356    0      2.105203e-14
C1336    #1357    0      2.105203e-14
C1337    #1358    0      2.105203e-14
C1338    #1359    0      2.105203e-14
C1339    #1343    0      2.381583e-14
C1340    #1344    0      2.405351e-14
C1341    #1137    0      2.044358e-13
C1342    #1138    0      2.052028e-13
C1343    #1139    0      2.037888e-13
C1344    #1140    0      2.042988e-13
C1345    #1141    0      2.037888e-13
C1346    #1142    0      2.042988e-13
C1347    #1143    0      2.037888e-13
C1348    #1144    0      2.042988e-13
C1349    #1145    0      2.037888e-13
C1350    #1146    0      2.042988e-13
C1351    #1147    0      2.037888e-13
C1352    #1148    0      2.042988e-13
C1353    #1149    0      2.037888e-13
C1354    #1150    0      2.046338e-13
C1355    #1151    0      2.051018e-13
C1356    #1377    0      5.728975e-13
C1357    #1480    0      8.728107e-15
C1358    #1448    0      9.504963e-15
C1359    #1451    0      9.504963e-15
C1360    #1453    0      9.504963e-15
C1361    #1455    0      9.504963e-15
C1362    #1457    0      9.504963e-15
C1363    #1459    0      9.504963e-15
C1364    #1461    0      9.504963e-15
C1365    #1463    0      9.504963e-15
C1366    #1449    0      9.745988e-15
C1367    #1465    0      9.503470e-15
C1368    #1466    0      9.503470e-15
C1369    #1450    0      9.745988e-15
C1370    #1467    0      9.503470e-15
C1371    #1468    0      9.503470e-15
C1372    #1452    0      9.745988e-15
C1373    #1469    0      9.503470e-15
C1374    #1470    0      9.503470e-15
C1375    #1454    0      9.745988e-15
C1376    #1471    0      9.503470e-15
C1377    #1472    0      9.503470e-15
C1378    #1456    0      9.745988e-15
C1379    #1473    0      9.503470e-15
C1380    #1474    0      9.503470e-15
C1381    #1458    0      9.745988e-15
C1382    #1475    0      9.503470e-15
C1383    #1476    0      9.503470e-15
C1384    #1460    0      9.745988e-15
C1385    #1477    0      9.503470e-15
C1386    #1478    0      9.503470e-15
C1387    #1462    0      9.745988e-15
C1388    #1479    0      9.503470e-15
C1389    #1481    0      8.884447e-15
C1390    #1464    0      9.745988e-15
C1391    #1427    0      7.362503e-14
C1392    #1411    0      7.464903e-14
C1393    #1412    0      7.593803e-14
C1394    #1413    0      7.817605e-14
C1395    #1414    0      7.655303e-14
C1396    #1415    0      7.817605e-14
C1397    #1416    0      7.655303e-14
C1398    #1417    0      7.817605e-14
C1399    #1418    0      7.655303e-14
C1400    #1419    0      7.817605e-14
C1401    #1420    0      7.655303e-14
C1402    #1421    0      7.817605e-14
C1403    #1422    0      7.655303e-14
C1404    #1423    0      7.817605e-14
C1405    #1424    0      7.655303e-14
C1406    #1425    0      8.012306e-14
C1407    #1426    0      7.740103e-14
C1408    #1483    0      7.785823e-15
C1409    #1484    0      7.807823e-15
C1410    #1485    0      7.807823e-15
C1411    #1486    0      7.807823e-15
C1412    #1487    0      7.807823e-15
C1413    #1488    0      7.807823e-15
C1414    #1489    0      7.807823e-15
C1415    #1490    0      7.807823e-15
C1416    #1491    0      7.807823e-15
C1417    #1492    0      7.807823e-15
C1418    #1493    0      7.807823e-15
C1419    #1494    0      7.807823e-15
C1420    #1495    0      7.807823e-15
C1421    #1496    0      7.807823e-15
C1422    #1497    0      7.807823e-15
C1423    #1498    0      7.807823e-15
C1424    #1499    0      7.807823e-15
C1425    #1500    0      8.294095e-15
C1426    #1501    0      8.316096e-15
C1427    #1502    0      8.316096e-15
C1428    #1503    0      8.316096e-15
C1429    #1504    0      8.316096e-15
C1430    #1505    0      8.316096e-15
C1431    #1506    0      8.316096e-15
C1432    #1507    0      8.316096e-15
C1433    #1508    0      8.316096e-15
C1434    #1509    0      8.316096e-15
C1435    #1510    0      8.316096e-15
C1436    #1511    0      8.316096e-15
C1437    #1512    0      8.316096e-15
C1438    #1513    0      8.316096e-15
C1439    #1514    0      8.316096e-15
C1440    #1515    0      8.316096e-15
C1441    #1516    0      8.316096e-15
C1442    #1482    0      4.797651e-13
C1443    #1438    0      3.475627e-14
C1444    #1392    0      6.122453e-14
C1445    #1431    0      3.414927e-14
C1446    #1378    0      6.932994e-14
C1447    #1440    0      3.404927e-14
C1448    #1379    0      6.666279e-14
C1449    #1432    0      3.394727e-14
C1450    #1380    0      6.585579e-14
C1451    #1441    0      3.404927e-14
C1452    #1381    0      6.658279e-14
C1453    #1433    0      3.394727e-14
C1454    #1382    0      6.585579e-14
C1455    #1442    0      3.404927e-14
C1456    #1383    0      6.658279e-14
C1457    #1434    0      3.394727e-14
C1458    #1384    0      6.585579e-14
C1459    #1443    0      3.404927e-14
C1460    #1385    0      6.658279e-14
C1461    #1435    0      3.394727e-14
C1462    #1386    0      6.585579e-14
C1463    #1444    0      3.404927e-14
C1464    #1387    0      6.658279e-14
C1465    #1436    0      3.394727e-14
C1466    #1388    0      6.585579e-14
C1467    #1445    0      3.404927e-14
C1468    #1389    0      6.658279e-14
C1469    #1437    0      3.394727e-14
C1470    #1390    0      6.585579e-14
C1471    #1446    0      3.404927e-14
C1472    #1391    0      6.658279e-14
C1473    #1439    0      3.483027e-14
C1474    #1375    0      6.842947e-14
C1475    #1447    0      3.500727e-14
C1476    #1376    0      7.420579e-14
C1477    #1552    0      2.752763e-14
C1478    #1555    0      5.125053e-15
C1479    #1554    0      1.425484e-14
C1480    #1518    0      1.869816e-14
C1481    #1340    0      1.016498e-13
C1482    #1557    0      1.042716e-14
C1483    #1410    0      2.168122e-13
C1484    #1576    0      1.269393e-14
C1485    #1577    0      1.120425e-14
C1486    #1579    0      1.729628e-14
C1487    #1522    0      5.261559e-14
C1488    #1523    0      5.231759e-14
C1489    #1524    0      5.261559e-14
C1490    #1525    0      5.231759e-14
C1491    #1526    0      5.261559e-14
C1492    #1527    0      5.231759e-14
C1493    #1528    0      5.261559e-14
C1494    #1529    0      5.231759e-14
C1495    #1530    0      5.261559e-14
C1496    #1531    0      5.231759e-14
C1497    #1532    0      5.261559e-14
C1498    #1533    0      5.231759e-14
C1499    #1534    0      5.261559e-14
C1500    #1535    0      5.231759e-14
C1501    #1536    0      5.261559e-14
C1502    #1537    0      4.925286e-14
C1503    #1538    0      4.954986e-14
C1504    #1539    0      4.925286e-14
C1505    #1540    0      4.954986e-14
C1506    #1541    0      4.925286e-14
C1507    #1542    0      4.954986e-14
C1508    #1543    0      4.925286e-14
C1509    #1544    0      4.954986e-14
C1510    #1545    0      4.925286e-14
C1511    #1546    0      4.954986e-14
C1512    #1547    0      4.925286e-14
C1513    #1548    0      4.954986e-14
C1514    #1549    0      4.925286e-14
C1515    #1550    0      4.954986e-14
C1516    #1551    0      4.925286e-14
C1517    #1578    0      4.459994e-14
C1518    X9       0      2.401746e-13
C1519    #1559    0      7.375704e-14
C1520    #1594    0      1.485837e-14
C1521    #1597    0      1.152330e-14
C1522    #1598    0      1.138806e-14
C1523    #1599    0      1.187606e-14
C1524    #1600    0      1.138806e-14
C1525    #1601    0      1.187606e-14
C1526    #1602    0      1.138806e-14
C1527    #1603    0      1.187606e-14
C1528    #1604    0      1.138806e-14
C1529    #1605    0      1.187606e-14
C1530    #1606    0      1.138806e-14
C1531    #1607    0      1.187606e-14
C1532    #1608    0      1.138806e-14
C1533    #1609    0      1.187606e-14
C1534    #1610    0      1.138806e-14
C1535    #1611    0      1.187606e-14
C1536    #1613    0      1.257959e-14
C1537    #1614    0      1.204059e-14
C1538    #1615    0      1.257959e-14
C1539    #1616    0      1.204059e-14
C1540    #1617    0      1.257959e-14
C1541    #1618    0      1.204059e-14
C1542    #1619    0      1.257959e-14
C1543    #1620    0      1.204059e-14
C1544    #1621    0      1.257959e-14
C1545    #1622    0      1.204059e-14
C1546    #1623    0      1.257959e-14
C1547    #1624    0      1.204059e-14
C1548    #1625    0      1.257959e-14
C1549    #1626    0      1.204059e-14
C1550    #1612    0      1.213392e-14
C1551    #1521    0      5.659915e-14
C1552    #1520    0      1.125410e-13
C1553    #1553    0      4.871851e-14
C1554    #1628    0      2.767863e-14
C1555    #1342    0      2.409255e-13
C1556    #1596    0      1.869816e-14
C1557    X8       0      1.581687e-13
C1558    #1664    0      3.773348e-15
C1559    #1663    0      1.063814e-14
C1560    #1662    0      7.188703e-14
C1561    #1630    0      2.105623e-14
C1562    #1632    0      2.109423e-14
C1563    #1634    0      2.109423e-14
C1564    #1636    0      2.109423e-14
C1565    #1638    0      2.109423e-14
C1566    #1640    0      2.109423e-14
C1567    #1642    0      2.109423e-14
C1568    #1644    0      2.109423e-14
C1569    #1645    0      2.007503e-14
C1570    #1646    0      2.007503e-14
C1571    #1647    0      2.007503e-14
C1572    #1648    0      2.007503e-14
C1573    #1649    0      2.007503e-14
C1574    #1650    0      2.007503e-14
C1575    #1651    0      2.007503e-14
C1576    #1652    0      2.007503e-14
C1577    #1653    0      2.007503e-14
C1578    #1654    0      2.007503e-14
C1579    #1655    0      2.007503e-14
C1580    #1656    0      2.007503e-14
C1581    #1657    0      2.007503e-14
C1582    #1517    0      1.067870e-13
C1583    #1658    0      2.007503e-14
C1584    #1659    0      2.007503e-14
C1585    #1631    0      2.113223e-14
C1586    #1633    0      2.113223e-14
C1587    #1635    0      2.113223e-14
C1588    #1637    0      2.113223e-14
C1589    #1639    0      2.113223e-14
C1590    #1641    0      2.113223e-14
C1591    #1643    0      2.113223e-14
C1592    #1660    0      2.812282e-14
C1593    #1170    0      1.249679e-13
C1594    #1661    0      2.613252e-14
C1595    #1580    0      9.687889e-14
C1596    #1581    0      9.687489e-14
C1597    #1582    0      9.669888e-14
C1598    #1583    0      9.672788e-14
C1599    #1584    0      9.669888e-14
C1600    #1585    0      9.672788e-14
C1601    #1586    0      9.669888e-14
C1602    #1587    0      9.672788e-14
C1603    #1588    0      9.669888e-14
C1604    #1589    0      9.672788e-14
C1605    #1590    0      9.669888e-14
C1606    #1591    0      9.672788e-14
C1607    #1592    0      9.669888e-14
C1608    #1593    0      9.672788e-14
C1609    #1429    0      8.572569e-14
C1610    Z24      0      3.657970e-14
C1611    #1682    0      1.056918e-14
C1612    #1683    0      1.048203e-14
C1613    #1684    0      1.048203e-14
C1614    #1685    0      1.048203e-14
C1615    #1686    0      1.048203e-14
C1616    #1687    0      1.048203e-14
C1617    #1688    0      1.048203e-14
C1618    #1689    0      1.048203e-14
C1619    #1690    0      1.048203e-14
C1620    #1691    0      1.048203e-14
C1621    #1692    0      1.048203e-14
C1622    #1693    0      1.048203e-14
C1623    #1694    0      1.048203e-14
C1624    #1695    0      1.048203e-14
C1625    #1696    0      1.048203e-14
C1626    #1665    0      7.911415e-14
C1627    #1428    0      1.673100e-13
C1628    #1697    0      9.993449e-15
C1629    #1326    0      1.840860e-13
C1630    #1698    0      9.993449e-15
C1631    #1334    0      1.872908e-13
C1632    #1699    0      9.993449e-15
C1633    #1327    0      1.844157e-13
C1634    #1700    0      9.993449e-15
C1635    #1335    0      1.872238e-13
C1636    #1701    0      9.993449e-15
C1637    #1328    0      1.844157e-13
C1638    #1702    0      9.993449e-15
C1639    #1336    0      1.872238e-13
C1640    #1703    0      9.993449e-15
C1641    #1329    0      1.844157e-13
C1642    #1704    0      9.993449e-15
C1643    #1337    0      1.872238e-13
C1644    #1705    0      9.993449e-15
C1645    #1330    0      1.844157e-13
C1646    #1706    0      9.993449e-15
C1647    #1338    0      1.872238e-13
C1648    #1707    0      9.993449e-15
C1649    #1331    0      1.844157e-13
C1650    #1708    0      9.993449e-15
C1651    #1339    0      1.872238e-13
C1652    #1709    0      9.993449e-15
C1653    #1332    0      1.844157e-13
C1654    #1710    0      9.993449e-15
C1655    #1430    0      7.071188e-13
C1656    #1711    0      1.015745e-14
C1657    #1712    0      1.132230e-14
C1658    #1575    0      1.444799e-13
C1659    #1713    0      1.227659e-14
C1660    #1715    0      1.153895e-14
C1661    #1717    0      1.153895e-14
C1662    #1719    0      1.153895e-14
C1663    #1721    0      1.153895e-14
C1664    #1723    0      1.153895e-14
C1665    #1725    0      1.153895e-14
C1666    #1727    0      1.153895e-14
C1667    #1730    0      1.213392e-14
C1668    #1732    0      1.213392e-14
C1669    #1734    0      1.213392e-14
C1670    #1736    0      1.213392e-14
C1671    #1738    0      1.213392e-14
C1672    #1740    0      1.213392e-14
C1673    #1742    0      1.213392e-14
C1674    #1745    0      1.148218e-14
C1675    #1731    0      1.306726e-14
C1676    #1733    0      1.306726e-14
C1677    #1735    0      1.306726e-14
C1678    #1737    0      1.306726e-14
C1679    #1739    0      1.306726e-14
C1680    #1741    0      1.306726e-14
C1681    #1743    0      1.306726e-14
C1682    #1716    0      1.395308e-14
C1683    #1718    0      1.395308e-14
C1684    #1720    0      1.395308e-14
C1685    #1722    0      1.395308e-14
C1686    #1724    0      1.395308e-14
C1687    #1726    0      1.395308e-14
C1688    #1728    0      1.395308e-14
C1689    #1333    0      1.974727e-13
C1690    #1746    0      1.227659e-14
C1691    #1744    0      1.428060e-14
C1692    #1714    0      1.606544e-14
C1693    #1595    0      4.989034e-14
C1694    #1748    0      4.250638e-15
C1695    #1681    0      4.283319e-14
C1696    Z23      0      1.684745e-14
C1697    #1729    0      1.192689e-14
C1698    #1629    0      3.734384e-14
C1699    #1674    0      6.952578e-14
C1700    #1667    0      6.808735e-14
C1701    #1675    0      6.903778e-14
C1702    #1668    0      6.808735e-14
C1703    #1676    0      6.903778e-14
C1704    #1669    0      6.808735e-14
C1705    #1677    0      6.903778e-14
C1706    #1670    0      6.808735e-14
C1707    #1678    0      6.903778e-14
C1708    #1671    0      6.808735e-14
C1709    #1679    0      6.903778e-14
C1710    #1672    0      6.808735e-14
C1711    #1680    0      6.903778e-14
C1712    #1673    0      6.808735e-14
C1713    #1666    0      6.505478e-14
C1714    #1767    0      1.143919e-14
C1715    #1783    0      9.595039e-15
C1716    #1784    0      1.106019e-14
C1717    #1785    0      1.106019e-14
C1718    #1786    0      1.106019e-14
C1719    #1787    0      1.106019e-14
C1720    #1788    0      1.106019e-14
C1721    #1789    0      1.106019e-14
C1722    #1790    0      1.106019e-14
C1723    #1791    0      1.106019e-14
C1724    #1792    0      1.106019e-14
C1725    #1793    0      1.106019e-14
C1726    #1794    0      1.106019e-14
C1727    #1795    0      1.106019e-14
C1728    #1796    0      1.106019e-14
C1729    #1797    0      1.106019e-14
C1730    #1816    0      8.235861e-15
C1731    #1766    0      2.148904e-14
C1732    #1768    0      2.148904e-14
C1733    #1817    0      7.845823e-15
C1734    #1818    0      7.845823e-15
C1735    #1819    0      7.845823e-15
C1736    #1820    0      7.845823e-15
C1737    #1821    0      7.845823e-15
C1738    #1822    0      7.845823e-15
C1739    #1823    0      7.845823e-15
C1740    #1824    0      7.845823e-15
C1741    #1825    0      7.845823e-15
C1742    #1826    0      7.845823e-15
C1743    #1827    0      7.845823e-15
C1744    #1828    0      7.845823e-15
C1745    #1829    0      7.845823e-15
C1746    #1830    0      7.845823e-15
C1747    #1831    0      7.845823e-15
C1748    #1832    0      7.845823e-15
C1749    #1765    0      5.502040e-13
C1750    #1769    0      2.105203e-14
C1751    #1770    0      2.105203e-14
C1752    #1771    0      2.105203e-14
C1753    #1772    0      2.105203e-14
C1754    #1773    0      2.105203e-14
C1755    #1774    0      2.105203e-14
C1756    #1775    0      2.105203e-14
C1757    #1776    0      2.105203e-14
C1758    #1777    0      2.105203e-14
C1759    #1778    0      2.105203e-14
C1760    #1779    0      2.105203e-14
C1761    #1780    0      2.105203e-14
C1762    #1781    0      2.105203e-14
C1763    #1782    0      2.105203e-14
C1764    #1560    0      2.044358e-13
C1765    #1561    0      2.052028e-13
C1766    #1562    0      2.037888e-13
C1767    #1563    0      2.042988e-13
C1768    #1564    0      2.037888e-13
C1769    #1565    0      2.042988e-13
C1770    #1566    0      2.037888e-13
C1771    #1567    0      2.042988e-13
C1772    #1568    0      2.037888e-13
C1773    #1569    0      2.042988e-13
C1774    #1570    0      2.037888e-13
C1775    #1571    0      2.042988e-13
C1776    #1572    0      2.037888e-13
C1777    #1573    0      2.045958e-13
C1778    #1574    0      2.049498e-13
C1779    #1800    0      5.727715e-13
C1780    #1903    0      8.728107e-15
C1781    #1871    0      9.504963e-15
C1782    #1874    0      9.504963e-15
C1783    #1876    0      9.504963e-15
C1784    #1878    0      9.504963e-15
C1785    #1880    0      9.504963e-15
C1786    #1882    0      9.504963e-15
C1787    #1884    0      9.504963e-15
C1788    #1886    0      9.504963e-15
C1789    #1872    0      9.745988e-15
C1790    #1888    0      9.503470e-15
C1791    #1889    0      9.503470e-15
C1792    #1873    0      9.745988e-15
C1793    #1890    0      9.503470e-15
C1794    #1891    0      9.503470e-15
C1795    #1875    0      9.745988e-15
C1796    #1892    0      9.503470e-15
C1797    #1893    0      9.503470e-15
C1798    #1877    0      9.745988e-15
C1799    #1894    0      9.503470e-15
C1800    #1895    0      9.503470e-15
C1801    #1879    0      9.745988e-15
C1802    #1896    0      9.503470e-15
C1803    #1897    0      9.503470e-15
C1804    #1881    0      9.745988e-15
C1805    #1898    0      9.503470e-15
C1806    #1899    0      9.503470e-15
C1807    #1883    0      9.745988e-15
C1808    #1900    0      9.503470e-15
C1809    #1901    0      9.503470e-15
C1810    #1885    0      9.745988e-15
C1811    #1902    0      9.503470e-15
C1812    #1904    0      8.884447e-15
C1813    #1887    0      9.745988e-15
C1814    #1850    0      7.362503e-14
C1815    #1834    0      7.464903e-14
C1816    #1835    0      7.593803e-14
C1817    #1836    0      7.817605e-14
C1818    #1837    0      7.655303e-14
C1819    #1838    0      7.817605e-14
C1820    #1839    0      7.655303e-14
C1821    #1840    0      7.817605e-14
C1822    #1841    0      7.655303e-14
C1823    #1842    0      7.817605e-14
C1824    #1843    0      7.655303e-14
C1825    #1844    0      7.817605e-14
C1826    #1845    0      7.655303e-14
C1827    #1846    0      7.817605e-14
C1828    #1847    0      7.655303e-14
C1829    #1848    0      7.902905e-14
C1830    #1849    0      7.689703e-14
C1831    #1906    0      7.785823e-15
C1832    #1907    0      7.807823e-15
C1833    #1908    0      7.807823e-15
C1834    #1909    0      7.807823e-15
C1835    #1910    0      7.807823e-15
C1836    #1911    0      7.807823e-15
C1837    #1912    0      7.807823e-15
C1838    #1913    0      7.807823e-15
C1839    #1914    0      7.807823e-15
C1840    #1915    0      7.807823e-15
C1841    #1916    0      7.807823e-15
C1842    #1917    0      7.807823e-15
C1843    #1918    0      7.807823e-15
C1844    #1919    0      7.807823e-15
C1845    #1920    0      7.807823e-15
C1846    #1921    0      7.807823e-15
C1847    #1922    0      7.807823e-15
C1848    #1923    0      8.294095e-15
C1849    #1924    0      8.316096e-15
C1850    #1925    0      8.316096e-15
C1851    #1926    0      8.316096e-15
C1852    #1927    0      8.316096e-15
C1853    #1928    0      8.316096e-15
C1854    #1929    0      8.316096e-15
C1855    #1930    0      8.316096e-15
C1856    #1931    0      8.316096e-15
C1857    #1932    0      8.316096e-15
C1858    #1933    0      8.316096e-15
C1859    #1934    0      8.316096e-15
C1860    #1935    0      8.316096e-15
C1861    #1936    0      8.316096e-15
C1862    #1937    0      8.316096e-15
C1863    #1938    0      8.316096e-15
C1864    #1939    0      8.316096e-15
C1865    #1905    0      4.792581e-13
C1866    #1862    0      3.475627e-14
C1867    #1815    0      6.122453e-14
C1868    #1854    0      3.414927e-14
C1869    #1801    0      6.932994e-14
C1870    #1863    0      3.404927e-14
C1871    #1802    0      6.666279e-14
C1872    #1855    0      3.394727e-14
C1873    #1803    0      6.585579e-14
C1874    #1864    0      3.404927e-14
C1875    #1804    0      6.658279e-14
C1876    #1856    0      3.394727e-14
C1877    #1805    0      6.585579e-14
C1878    #1865    0      3.404927e-14
C1879    #1806    0      6.658279e-14
C1880    #1857    0      3.394727e-14
C1881    #1807    0      6.585579e-14
C1882    #1866    0      3.404927e-14
C1883    #1808    0      6.658279e-14
C1884    #1858    0      3.394727e-14
C1885    #1809    0      6.585579e-14
C1886    #1867    0      3.404927e-14
C1887    #1810    0      6.658279e-14
C1888    #1859    0      3.394727e-14
C1889    #1811    0      6.585579e-14
C1890    #1868    0      3.404927e-14
C1891    #1812    0      6.658279e-14
C1892    #1860    0      3.394727e-14
C1893    #1813    0      6.585579e-14
C1894    #1869    0      3.404927e-14
C1895    #1814    0      6.658279e-14
C1896    #1861    0      3.463027e-14
C1897    #1799    0      6.751379e-14
C1898    #1870    0      3.471027e-14
C1899    #1798    0      7.387979e-14
C1900    #1976    0      2.752763e-14
C1901    #1977    0      1.470808e-14
C1902    #1975    0      1.863045e-14
C1903    #1941    0      1.869816e-14
C1904    #1763    0      1.023898e-13
C1905    #1979    0      1.042716e-14
C1906    #1981    0      1.222359e-14
C1907    #1833    0      2.168122e-13
C1908    #1983    0      1.232059e-14
C1909    #1943    0      4.493020e-14
C1910    #2001    0      1.120425e-14
C1911    #1945    0      5.261559e-14
C1912    #1946    0      5.231759e-14
C1913    #1947    0      5.261559e-14
C1914    #1948    0      5.231759e-14
C1915    #1949    0      5.261559e-14
C1916    #1950    0      5.231759e-14
C1917    #1951    0      5.261559e-14
C1918    #1952    0      5.231759e-14
C1919    #1953    0      5.261559e-14
C1920    #1954    0      5.231759e-14
C1921    #1955    0      5.261559e-14
C1922    #1956    0      5.231759e-14
C1923    #1957    0      5.261559e-14
C1924    #1958    0      5.231759e-14
C1925    #1959    0      5.261559e-14
C1926    #1960    0      4.925286e-14
C1927    #1961    0      4.954986e-14
C1928    #1962    0      4.925286e-14
C1929    #1963    0      4.954986e-14
C1930    #1964    0      4.925286e-14
C1931    #1965    0      4.954986e-14
C1932    #1966    0      4.925286e-14
C1933    #1967    0      4.954986e-14
C1934    #1968    0      4.925286e-14
C1935    #1969    0      4.954986e-14
C1936    #1970    0      4.925286e-14
C1937    #1971    0      4.954986e-14
C1938    #1972    0      4.925286e-14
C1939    #1973    0      4.954986e-14
C1940    #1974    0      4.925286e-14
C1941    #2003    0      1.455661e-14
C1942    #2000    0      4.465194e-14
C1943    X7       0      2.401746e-13
C1944    #1984    0      7.375704e-14
C1945    #2020    0      1.455608e-14
C1946    #1942    0      8.458875e-14
C1947    #2002    0      1.922745e-14
C1948    #1980    0      4.953397e-14
C1949    #2022    0      1.152330e-14
C1950    #2023    0      1.138806e-14
C1951    #2024    0      1.187606e-14
C1952    #2025    0      1.138806e-14
C1953    #2026    0      1.187606e-14
C1954    #2027    0      1.138806e-14
C1955    #2028    0      1.187606e-14
C1956    #2029    0      1.138806e-14
C1957    #2030    0      1.187606e-14
C1958    #2031    0      1.138806e-14
C1959    #2032    0      1.187606e-14
C1960    #2033    0      1.138806e-14
C1961    #2034    0      1.187606e-14
C1962    #2035    0      1.138806e-14
C1963    #2036    0      1.187606e-14
C1964    #2038    0      1.257959e-14
C1965    #2039    0      1.204059e-14
C1966    #2040    0      1.257959e-14
C1967    #2041    0      1.204059e-14
C1968    #2042    0      1.257959e-14
C1969    #2043    0      1.204059e-14
C1970    #2044    0      1.257959e-14
C1971    #2045    0      1.204059e-14
C1972    #2046    0      1.257959e-14
C1973    #2047    0      1.204059e-14
C1974    #2048    0      1.257959e-14
C1975    #2049    0      1.204059e-14
C1976    #2050    0      1.257959e-14
C1977    #2051    0      1.204059e-14
C1978    #2037    0      1.213392e-14
C1979    #2053    0      2.767863e-14
C1980    #1764    0      2.409255e-13
C1981    #1558    0      1.054867e-13
C1982    #2021    0      1.869816e-14
C1983    X6       0      1.581687e-13
C1984    #2089    0      3.773348e-15
C1985    #2090    0      1.063814e-14
C1986    #2087    0      7.188703e-14
C1987    #2057    0      2.105623e-14
C1988    #2059    0      2.109423e-14
C1989    #2061    0      2.109423e-14
C1990    #2063    0      2.109423e-14
C1991    #2065    0      2.109423e-14
C1992    #2067    0      2.109423e-14
C1993    #2069    0      2.109423e-14
C1994    #2071    0      2.109423e-14
C1995    #2072    0      2.007503e-14
C1996    #2073    0      2.007503e-14
C1997    #2074    0      2.007503e-14
C1998    #2075    0      2.007503e-14
C1999    #2076    0      2.007503e-14
C2000    #2077    0      2.007503e-14
C2001    #2078    0      2.007503e-14
C2002    #2079    0      2.007503e-14
C2003    #2080    0      2.007503e-14
C2004    #2081    0      2.007503e-14
C2005    #2082    0      2.007503e-14
C2006    #2083    0      2.007503e-14
C2007    #2084    0      2.007503e-14
C2008    #1940    0      1.075261e-13
C2009    #2085    0      2.007503e-14
C2010    #2086    0      2.007503e-14
C2011    #2058    0      2.113223e-14
C2012    #2060    0      2.113223e-14
C2013    #2062    0      2.113223e-14
C2014    #2064    0      2.113223e-14
C2015    #2066    0      2.113223e-14
C2016    #2068    0      2.113223e-14
C2017    #2070    0      2.113223e-14
C2018    #2054    0      2.917067e-14
C2019    #2056    0      2.471003e-14
C2020    #2055    0      2.694664e-14
C2021    #2004    0      9.687889e-14
C2022    #2005    0      9.687489e-14
C2023    #2006    0      9.669888e-14
C2024    #2007    0      9.672788e-14
C2025    #2008    0      9.669888e-14
C2026    #2009    0      9.672788e-14
C2027    #2010    0      9.669888e-14
C2028    #2011    0      9.672788e-14
C2029    #2012    0      9.669888e-14
C2030    #2013    0      9.672788e-14
C2031    #2014    0      9.669888e-14
C2032    #2015    0      9.672788e-14
C2033    #2016    0      9.669888e-14
C2034    #2017    0      9.672788e-14
C2035    #1852    0      8.572569e-14
C2036    Z22      0      3.714827e-14
C2037    #2107    0      1.056918e-14
C2038    #2108    0      1.048203e-14
C2039    #2109    0      1.048203e-14
C2040    #2110    0      1.048203e-14
C2041    #2111    0      1.048203e-14
C2042    #2112    0      1.048203e-14
C2043    #2113    0      1.048203e-14
C2044    #2114    0      1.048203e-14
C2045    #2115    0      1.048203e-14
C2046    #2116    0      1.048203e-14
C2047    #2117    0      1.048203e-14
C2048    #2118    0      1.048203e-14
C2049    #2119    0      1.048203e-14
C2050    #2120    0      1.048203e-14
C2051    #2121    0      1.048203e-14
C2052    #2088    0      7.901629e-14
C2053    #2137    0      1.132230e-14
C2054    #1851    0      1.673100e-13
C2055    #2122    0      9.993449e-15
C2056    #1749    0      1.840860e-13
C2057    #2123    0      9.993449e-15
C2058    #1757    0      1.872908e-13
C2059    #2124    0      9.993449e-15
C2060    #1750    0      1.844157e-13
C2061    #2125    0      9.993449e-15
C2062    #1758    0      1.872238e-13
C2063    #2126    0      9.993449e-15
C2064    #1751    0      1.844157e-13
C2065    #2127    0      9.993449e-15
C2066    #1759    0      1.872238e-13
C2067    #2128    0      9.993449e-15
C2068    #1752    0      1.844157e-13
C2069    #2129    0      9.993449e-15
C2070    #1760    0      1.872238e-13
C2071    #2130    0      9.993449e-15
C2072    #1753    0      1.844157e-13
C2073    #2131    0      9.993449e-15
C2074    #1761    0      1.872238e-13
C2075    #2132    0      9.993449e-15
C2076    #1754    0      1.844157e-13
C2077    #2133    0      9.993449e-15
C2078    #1762    0      1.872238e-13
C2079    #2134    0      9.993449e-15
C2080    #1755    0      1.844157e-13
C2081    #2135    0      9.993449e-15
C2082    #1853    0      7.070788e-13
C2083    #2136    0      1.015745e-14
C2084    #1982    0      1.378873e-13
C2085    #2138    0      1.227659e-14
C2086    #2155    0      1.132230e-14
C2087    #2140    0      1.153895e-14
C2088    #2142    0      1.153895e-14
C2089    #2144    0      1.153895e-14
C2090    #2146    0      1.153895e-14
C2091    #2148    0      1.153895e-14
C2092    #2150    0      1.153895e-14
C2093    #2152    0      1.153895e-14
C2094    #2156    0      1.213392e-14
C2095    #2158    0      1.213392e-14
C2096    #2160    0      1.213392e-14
C2097    #2162    0      1.213392e-14
C2098    #2164    0      1.213392e-14
C2099    #2166    0      1.213392e-14
C2100    #2168    0      1.213392e-14
C2101    #1756    0      1.628715e-13
C2102    #2171    0      1.289259e-14
C2103    #2157    0      1.306726e-14
C2104    #2159    0      1.306726e-14
C2105    #2161    0      1.306726e-14
C2106    #2163    0      1.306726e-14
C2107    #2165    0      1.306726e-14
C2108    #2167    0      1.306726e-14
C2109    #2169    0      1.306726e-14
C2110    #2141    0      1.395308e-14
C2111    #2143    0      1.395308e-14
C2112    #2145    0      1.395308e-14
C2113    #2147    0      1.395308e-14
C2114    #2149    0      1.395308e-14
C2115    #2151    0      1.395308e-14
C2116    #2153    0      1.395308e-14
C2117    #2170    0      1.428060e-14
C2118    #2139    0      1.606544e-14
C2119    #2019    0      4.944033e-14
C2120    #2173    0      4.250638e-15
C2121    #2106    0      4.351619e-14
C2122    Z21      0      1.684745e-14
C2123    #2154    0      1.209989e-14
C2124    #2099    0      6.952578e-14
C2125    #2092    0      6.808735e-14
C2126    #2100    0      6.903778e-14
C2127    #2093    0      6.808735e-14
C2128    #2101    0      6.903778e-14
C2129    #2094    0      6.808735e-14
C2130    #2102    0      6.903778e-14
C2131    #2095    0      6.808735e-14
C2132    #2103    0      6.903778e-14
C2133    #2096    0      6.808735e-14
C2134    #2104    0      6.903778e-14
C2135    #2097    0      6.808735e-14
C2136    #2105    0      6.903778e-14
C2137    #2098    0      6.808735e-14
C2138    #2091    0      6.505478e-14
C2139    #2193    0      1.143919e-14
C2140    #2208    0      9.595039e-15
C2141    #2209    0      1.106019e-14
C2142    #2210    0      1.106019e-14
C2143    #2211    0      1.106019e-14
C2144    #2212    0      1.106019e-14
C2145    #2213    0      1.106019e-14
C2146    #2214    0      1.106019e-14
C2147    #2215    0      1.106019e-14
C2148    #2216    0      1.106019e-14
C2149    #2217    0      1.106019e-14
C2150    #2218    0      1.106019e-14
C2151    #2219    0      1.106019e-14
C2152    #2220    0      1.106019e-14
C2153    #2221    0      1.106019e-14
C2154    #2222    0      1.106019e-14
C2155    #2241    0      8.235861e-15
C2156    #2242    0      7.845823e-15
C2157    #2243    0      7.845823e-15
C2158    #2244    0      7.845823e-15
C2159    #2245    0      7.845823e-15
C2160    #2246    0      7.845823e-15
C2161    #2247    0      7.845823e-15
C2162    #2248    0      7.845823e-15
C2163    #2249    0      7.845823e-15
C2164    #2250    0      7.845823e-15
C2165    #2251    0      7.845823e-15
C2166    #2252    0      7.845823e-15
C2167    #2253    0      7.845823e-15
C2168    #2254    0      7.845823e-15
C2169    #2255    0      7.845823e-15
C2170    #2256    0      7.845823e-15
C2171    #2257    0      7.845823e-15
C2172    #2189    0      5.502429e-13
C2173    #2194    0      2.105203e-14
C2174    #2195    0      2.105203e-14
C2175    #2196    0      2.105203e-14
C2176    #2197    0      2.105203e-14
C2177    #2198    0      2.105203e-14
C2178    #2199    0      2.105203e-14
C2179    #2200    0      2.105203e-14
C2180    #2201    0      2.105203e-14
C2181    #2202    0      2.105203e-14
C2182    #2203    0      2.105203e-14
C2183    #2204    0      2.105203e-14
C2184    #2205    0      2.105203e-14
C2185    #2206    0      2.105203e-14
C2186    #2207    0      2.105203e-14
C2187    #2191    0      2.381583e-14
C2188    #2192    0      2.405351e-14
C2189    #1985    0      2.044358e-13
C2190    #1986    0      2.052028e-13
C2191    #1987    0      2.037888e-13
C2192    #1988    0      2.042988e-13
C2193    #1989    0      2.037888e-13
C2194    #1990    0      2.042988e-13
C2195    #1991    0      2.037888e-13
C2196    #1992    0      2.042988e-13
C2197    #1993    0      2.037888e-13
C2198    #1994    0      2.042988e-13
C2199    #1995    0      2.037888e-13
C2200    #1996    0      2.042988e-13
C2201    #1997    0      2.037888e-13
C2202    #1998    0      2.046338e-13
C2203    #1999    0      2.051018e-13
C2204    #2225    0      5.728975e-13
C2205    #2328    0      8.728107e-15
C2206    #2296    0      9.504963e-15
C2207    #2299    0      9.504963e-15
C2208    #2301    0      9.504963e-15
C2209    #2303    0      9.504963e-15
C2210    #2305    0      9.504963e-15
C2211    #2307    0      9.504963e-15
C2212    #2309    0      9.504963e-15
C2213    #2311    0      9.504963e-15
C2214    #2297    0      9.745988e-15
C2215    #2313    0      9.503470e-15
C2216    #2314    0      9.503470e-15
C2217    #2298    0      9.745988e-15
C2218    #2315    0      9.503470e-15
C2219    #2316    0      9.503470e-15
C2220    #2300    0      9.745988e-15
C2221    #2317    0      9.503470e-15
C2222    #2318    0      9.503470e-15
C2223    #2302    0      9.745988e-15
C2224    #2319    0      9.503470e-15
C2225    #2320    0      9.503470e-15
C2226    #2304    0      9.745988e-15
C2227    #2321    0      9.503470e-15
C2228    #2322    0      9.503470e-15
C2229    #2306    0      9.745988e-15
C2230    #2323    0      9.503470e-15
C2231    #2324    0      9.503470e-15
C2232    #2308    0      9.745988e-15
C2233    #2325    0      9.503470e-15
C2234    #2326    0      9.503470e-15
C2235    #2310    0      9.745988e-15
C2236    #2327    0      9.503470e-15
C2237    #2329    0      8.884447e-15
C2238    #2312    0      9.745988e-15
C2239    #2275    0      7.362503e-14
C2240    #2259    0      7.464903e-14
C2241    #2260    0      7.593803e-14
C2242    #2261    0      7.817605e-14
C2243    #2262    0      7.655303e-14
C2244    #2263    0      7.817605e-14
C2245    #2264    0      7.655303e-14
C2246    #2265    0      7.817605e-14
C2247    #2266    0      7.655303e-14
C2248    #2267    0      7.817605e-14
C2249    #2268    0      7.655303e-14
C2250    #2269    0      7.817605e-14
C2251    #2270    0      7.655303e-14
C2252    #2271    0      7.817605e-14
C2253    #2272    0      7.655303e-14
C2254    #2273    0      8.012306e-14
C2255    #2274    0      7.740103e-14
C2256    #2331    0      7.785823e-15
C2257    #2332    0      7.807823e-15
C2258    #2333    0      7.807823e-15
C2259    #2334    0      7.807823e-15
C2260    #2335    0      7.807823e-15
C2261    #2336    0      7.807823e-15
C2262    #2337    0      7.807823e-15
C2263    #2338    0      7.807823e-15
C2264    #2339    0      7.807823e-15
C2265    #2340    0      7.807823e-15
C2266    #2341    0      7.807823e-15
C2267    #2342    0      7.807823e-15
C2268    #2343    0      7.807823e-15
C2269    #2344    0      7.807823e-15
C2270    #2345    0      7.807823e-15
C2271    #2346    0      7.807823e-15
C2272    #2347    0      7.807823e-15
C2273    #2348    0      8.294095e-15
C2274    #2349    0      8.316096e-15
C2275    #2350    0      8.316096e-15
C2276    #2351    0      8.316096e-15
C2277    #2352    0      8.316096e-15
C2278    #2353    0      8.316096e-15
C2279    #2354    0      8.316096e-15
C2280    #2355    0      8.316096e-15
C2281    #2356    0      8.316096e-15
C2282    #2357    0      8.316096e-15
C2283    #2358    0      8.316096e-15
C2284    #2359    0      8.316096e-15
C2285    #2360    0      8.316096e-15
C2286    #2361    0      8.316096e-15
C2287    #2362    0      8.316096e-15
C2288    #2363    0      8.316096e-15
C2289    #2364    0      8.316096e-15
C2290    #2330    0      4.797651e-13
C2291    #2286    0      3.475627e-14
C2292    #2240    0      6.122453e-14
C2293    #2279    0      3.414927e-14
C2294    #2226    0      6.932994e-14
C2295    #2288    0      3.404927e-14
C2296    #2227    0      6.666279e-14
C2297    #2280    0      3.394727e-14
C2298    #2228    0      6.585579e-14
C2299    #2289    0      3.404927e-14
C2300    #2229    0      6.658279e-14
C2301    #2281    0      3.394727e-14
C2302    #2230    0      6.585579e-14
C2303    #2290    0      3.404927e-14
C2304    #2231    0      6.658279e-14
C2305    #2282    0      3.394727e-14
C2306    #2232    0      6.585579e-14
C2307    #2291    0      3.404927e-14
C2308    #2233    0      6.658279e-14
C2309    #2283    0      3.394727e-14
C2310    #2234    0      6.585579e-14
C2311    #2292    0      3.404927e-14
C2312    #2235    0      6.658279e-14
C2313    #2284    0      3.394727e-14
C2314    #2236    0      6.585579e-14
C2315    #2293    0      3.404927e-14
C2316    #2237    0      6.658279e-14
C2317    #2285    0      3.394727e-14
C2318    #2238    0      6.585579e-14
C2319    #2294    0      3.404927e-14
C2320    #2239    0      6.658279e-14
C2321    #2287    0      3.483027e-14
C2322    #2223    0      6.842947e-14
C2323    #2295    0      3.500727e-14
C2324    #2224    0      7.420579e-14
C2325    #2400    0      2.752763e-14
C2326    #2403    0      5.125053e-15
C2327    #2402    0      1.425484e-14
C2328    #2366    0      1.869816e-14
C2329    #2188    0      1.016498e-13
C2330    #2405    0      1.042716e-14
C2331    #2258    0      2.168122e-13
C2332    #2424    0      1.269393e-14
C2333    #2425    0      1.120425e-14
C2334    #2427    0      1.729628e-14
C2335    #2370    0      5.261559e-14
C2336    #2371    0      5.231759e-14
C2337    #2372    0      5.261559e-14
C2338    #2373    0      5.231759e-14
C2339    #2374    0      5.261559e-14
C2340    #2375    0      5.231759e-14
C2341    #2376    0      5.261559e-14
C2342    #2377    0      5.231759e-14
C2343    #2378    0      5.261559e-14
C2344    #2379    0      5.231759e-14
C2345    #2380    0      5.261559e-14
C2346    #2381    0      5.231759e-14
C2347    #2382    0      5.261559e-14
C2348    #2383    0      5.231759e-14
C2349    #2384    0      5.261559e-14
C2350    #2385    0      4.925286e-14
C2351    #2386    0      4.954986e-14
C2352    #2387    0      4.925286e-14
C2353    #2388    0      4.954986e-14
C2354    #2389    0      4.925286e-14
C2355    #2390    0      4.954986e-14
C2356    #2391    0      4.925286e-14
C2357    #2392    0      4.954986e-14
C2358    #2393    0      4.925286e-14
C2359    #2394    0      4.954986e-14
C2360    #2395    0      4.925286e-14
C2361    #2396    0      4.954986e-14
C2362    #2397    0      4.925286e-14
C2363    #2398    0      4.954986e-14
C2364    #2399    0      4.925286e-14
C2365    #2426    0      4.459994e-14
C2366    X5       0      2.401746e-13
C2367    #2407    0      7.375704e-14
C2368    #2442    0      1.485837e-14
C2369    #2445    0      1.152330e-14
C2370    #2446    0      1.138806e-14
C2371    #2447    0      1.187606e-14
C2372    #2448    0      1.138806e-14
C2373    #2449    0      1.187606e-14
C2374    #2450    0      1.138806e-14
C2375    #2451    0      1.187606e-14
C2376    #2452    0      1.138806e-14
C2377    #2453    0      1.187606e-14
C2378    #2454    0      1.138806e-14
C2379    #2455    0      1.187606e-14
C2380    #2456    0      1.138806e-14
C2381    #2457    0      1.187606e-14
C2382    #2458    0      1.138806e-14
C2383    #2459    0      1.187606e-14
C2384    #2461    0      1.257959e-14
C2385    #2462    0      1.204059e-14
C2386    #2463    0      1.257959e-14
C2387    #2464    0      1.204059e-14
C2388    #2465    0      1.257959e-14
C2389    #2466    0      1.204059e-14
C2390    #2467    0      1.257959e-14
C2391    #2468    0      1.204059e-14
C2392    #2469    0      1.257959e-14
C2393    #2470    0      1.204059e-14
C2394    #2471    0      1.257959e-14
C2395    #2472    0      1.204059e-14
C2396    #2473    0      1.257959e-14
C2397    #2474    0      1.204059e-14
C2398    #2460    0      1.213392e-14
C2399    #2369    0      5.659915e-14
C2400    #2368    0      1.125410e-13
C2401    #2401    0      4.871851e-14
C2402    #2476    0      2.767863e-14
C2403    #2190    0      2.409255e-13
C2404    #2444    0      1.869816e-14
C2405    X4       0      1.581687e-13
C2406    #2512    0      3.773348e-15
C2407    #2511    0      1.063814e-14
C2408    #2510    0      7.188703e-14
C2409    #2478    0      2.105623e-14
C2410    #2480    0      2.109423e-14
C2411    #2482    0      2.109423e-14
C2412    #2484    0      2.109423e-14
C2413    #2486    0      2.109423e-14
C2414    #2488    0      2.109423e-14
C2415    #2490    0      2.109423e-14
C2416    #2492    0      2.109423e-14
C2417    #2493    0      2.007503e-14
C2418    #2494    0      2.007503e-14
C2419    #2495    0      2.007503e-14
C2420    #2496    0      2.007503e-14
C2421    #2497    0      2.007503e-14
C2422    #2498    0      2.007503e-14
C2423    #2499    0      2.007503e-14
C2424    #2500    0      2.007503e-14
C2425    #2501    0      2.007503e-14
C2426    #2502    0      2.007503e-14
C2427    #2503    0      2.007503e-14
C2428    #2504    0      2.007503e-14
C2429    #2505    0      2.007503e-14
C2430    #2365    0      1.067870e-13
C2431    #2506    0      2.007503e-14
C2432    #2507    0      2.007503e-14
C2433    #2479    0      2.113223e-14
C2434    #2481    0      2.113223e-14
C2435    #2483    0      2.113223e-14
C2436    #2485    0      2.113223e-14
C2437    #2487    0      2.113223e-14
C2438    #2489    0      2.113223e-14
C2439    #2491    0      2.113223e-14
C2440    #2508    0      2.812282e-14
C2441    #2018    0      1.249679e-13
C2442    #2509    0      2.613252e-14
C2443    #2428    0      9.687889e-14
C2444    #2429    0      9.687489e-14
C2445    #2430    0      9.669888e-14
C2446    #2431    0      9.672788e-14
C2447    #2432    0      9.669888e-14
C2448    #2433    0      9.672788e-14
C2449    #2434    0      9.669888e-14
C2450    #2435    0      9.672788e-14
C2451    #2436    0      9.669888e-14
C2452    #2437    0      9.672788e-14
C2453    #2438    0      9.669888e-14
C2454    #2439    0      9.672788e-14
C2455    #2440    0      9.669888e-14
C2456    #2441    0      9.672788e-14
C2457    #2277    0      8.572569e-14
C2458    Z20      0      3.657970e-14
C2459    #2530    0      1.056918e-14
C2460    #2531    0      1.048203e-14
C2461    #2532    0      1.048203e-14
C2462    #2533    0      1.048203e-14
C2463    #2534    0      1.048203e-14
C2464    #2535    0      1.048203e-14
C2465    #2536    0      1.048203e-14
C2466    #2537    0      1.048203e-14
C2467    #2538    0      1.048203e-14
C2468    #2539    0      1.048203e-14
C2469    #2540    0      1.048203e-14
C2470    #2541    0      1.048203e-14
C2471    #2542    0      1.048203e-14
C2472    #2543    0      1.048203e-14
C2473    #2544    0      1.048203e-14
C2474    #2513    0      7.911415e-14
C2475    #2276    0      1.673100e-13
C2476    #2545    0      9.993449e-15
C2477    #2174    0      1.840860e-13
C2478    #2546    0      9.993449e-15
C2479    #2182    0      1.872908e-13
C2480    #2547    0      9.993449e-15
C2481    #2175    0      1.844157e-13
C2482    #2548    0      9.993449e-15
C2483    #2183    0      1.872238e-13
C2484    #2549    0      9.993449e-15
C2485    #2176    0      1.844157e-13
C2486    #2550    0      9.993449e-15
C2487    #2184    0      1.872238e-13
C2488    #2551    0      9.993449e-15
C2489    #2177    0      1.844157e-13
C2490    #2552    0      9.993449e-15
C2491    #2185    0      1.872238e-13
C2492    #2553    0      9.993449e-15
C2493    #2178    0      1.844157e-13
C2494    #2554    0      9.993449e-15
C2495    #2186    0      1.872238e-13
C2496    #2555    0      9.993449e-15
C2497    #2179    0      1.844157e-13
C2498    #2556    0      9.993449e-15
C2499    #2187    0      1.872238e-13
C2500    #2557    0      9.993449e-15
C2501    #2180    0      1.844157e-13
C2502    #2558    0      9.993449e-15
C2503    #2278    0      7.071188e-13
C2504    #2559    0      1.015745e-14
C2505    #2560    0      1.132230e-14
C2506    #2423    0      1.444799e-13
C2507    #2561    0      1.227659e-14
C2508    #2563    0      1.153895e-14
C2509    #2565    0      1.153895e-14
C2510    #2567    0      1.153895e-14
C2511    #2569    0      1.153895e-14
C2512    #2571    0      1.153895e-14
C2513    #2573    0      1.153895e-14
C2514    #2575    0      1.153895e-14
C2515    #2578    0      1.213392e-14
C2516    #2580    0      1.213392e-14
C2517    #2582    0      1.213392e-14
C2518    #2584    0      1.213392e-14
C2519    #2586    0      1.213392e-14
C2520    #2588    0      1.213392e-14
C2521    #2590    0      1.213392e-14
C2522    #2593    0      1.148218e-14
C2523    #2579    0      1.306726e-14
C2524    #2581    0      1.306726e-14
C2525    #2583    0      1.306726e-14
C2526    #2585    0      1.306726e-14
C2527    #2587    0      1.306726e-14
C2528    #2589    0      1.306726e-14
C2529    #2591    0      1.306726e-14
C2530    #2564    0      1.395308e-14
C2531    #2566    0      1.395308e-14
C2532    #2568    0      1.395308e-14
C2533    #2570    0      1.395308e-14
C2534    #2572    0      1.395308e-14
C2535    #2574    0      1.395308e-14
C2536    #2576    0      1.395308e-14
C2537    #2181    0      1.974727e-13
C2538    #2594    0      1.227659e-14
C2539    #2592    0      1.428060e-14
C2540    #2562    0      1.606544e-14
C2541    #2443    0      4.989034e-14
C2542    #2596    0      4.250638e-15
C2543    #2529    0      4.283319e-14
C2544    Z19      0      1.684745e-14
C2545    #2577    0      1.192689e-14
C2546    #2477    0      3.734384e-14
C2547    #2522    0      6.952578e-14
C2548    #2515    0      6.808735e-14
C2549    #2523    0      6.903778e-14
C2550    #2516    0      6.808735e-14
C2551    #2524    0      6.903778e-14
C2552    #2517    0      6.808735e-14
C2553    #2525    0      6.903778e-14
C2554    #2518    0      6.808735e-14
C2555    #2526    0      6.903778e-14
C2556    #2519    0      6.808735e-14
C2557    #2527    0      6.903778e-14
C2558    #2520    0      6.808735e-14
C2559    #2528    0      6.903778e-14
C2560    #2521    0      6.808735e-14
C2561    #2514    0      6.505478e-14
C2562    #2615    0      1.143919e-14
C2563    #2631    0      9.595039e-15
C2564    #2632    0      1.106019e-14
C2565    #2633    0      1.106019e-14
C2566    #2634    0      1.106019e-14
C2567    #2635    0      1.106019e-14
C2568    #2636    0      1.106019e-14
C2569    #2637    0      1.106019e-14
C2570    #2638    0      1.106019e-14
C2571    #2639    0      1.106019e-14
C2572    #2640    0      1.106019e-14
C2573    #2641    0      1.106019e-14
C2574    #2642    0      1.106019e-14
C2575    #2643    0      1.106019e-14
C2576    #2644    0      1.106019e-14
C2577    #2645    0      1.106019e-14
C2578    #2664    0      8.235861e-15
C2579    #2614    0      2.148904e-14
C2580    #2616    0      2.148904e-14
C2581    #2665    0      7.845823e-15
C2582    #2666    0      7.845823e-15
C2583    #2667    0      7.845823e-15
C2584    #2668    0      7.845823e-15
C2585    #2669    0      7.845823e-15
C2586    #2670    0      7.845823e-15
C2587    #2671    0      7.845823e-15
C2588    #2672    0      7.845823e-15
C2589    #2673    0      7.845823e-15
C2590    #2674    0      7.845823e-15
C2591    #2675    0      7.845823e-15
C2592    #2676    0      7.845823e-15
C2593    #2677    0      7.845823e-15
C2594    #2678    0      7.845823e-15
C2595    #2679    0      7.845823e-15
C2596    #2680    0      7.845823e-15
C2597    #2613    0      5.502040e-13
C2598    #2617    0      2.105203e-14
C2599    #2618    0      2.105203e-14
C2600    #2619    0      2.105203e-14
C2601    #2620    0      2.105203e-14
C2602    #2621    0      2.105203e-14
C2603    #2622    0      2.105203e-14
C2604    #2623    0      2.105203e-14
C2605    #2624    0      2.105203e-14
C2606    #2625    0      2.105203e-14
C2607    #2626    0      2.105203e-14
C2608    #2627    0      2.105203e-14
C2609    #2628    0      2.105203e-14
C2610    #2629    0      2.105203e-14
C2611    #2630    0      2.105203e-14
C2612    #2408    0      2.044358e-13
C2613    #2409    0      2.052028e-13
C2614    #2410    0      2.037888e-13
C2615    #2411    0      2.042988e-13
C2616    #2412    0      2.037888e-13
C2617    #2413    0      2.042988e-13
C2618    #2414    0      2.037888e-13
C2619    #2415    0      2.042988e-13
C2620    #2416    0      2.037888e-13
C2621    #2417    0      2.042988e-13
C2622    #2418    0      2.037888e-13
C2623    #2419    0      2.042988e-13
C2624    #2420    0      2.037888e-13
C2625    #2421    0      2.045958e-13
C2626    #2422    0      2.049498e-13
C2627    #2648    0      5.727715e-13
C2628    #2751    0      8.728107e-15
C2629    #2719    0      9.504963e-15
C2630    #2722    0      9.504963e-15
C2631    #2724    0      9.504963e-15
C2632    #2726    0      9.504963e-15
C2633    #2728    0      9.504963e-15
C2634    #2730    0      9.504963e-15
C2635    #2732    0      9.504963e-15
C2636    #2734    0      9.504963e-15
C2637    #2720    0      9.745988e-15
C2638    #2736    0      9.503470e-15
C2639    #2737    0      9.503470e-15
C2640    #2721    0      9.745988e-15
C2641    #2738    0      9.503470e-15
C2642    #2739    0      9.503470e-15
C2643    #2723    0      9.745988e-15
C2644    #2740    0      9.503470e-15
C2645    #2741    0      9.503470e-15
C2646    #2725    0      9.745988e-15
C2647    #2742    0      9.503470e-15
C2648    #2743    0      9.503470e-15
C2649    #2727    0      9.745988e-15
C2650    #2744    0      9.503470e-15
C2651    #2745    0      9.503470e-15
C2652    #2729    0      9.745988e-15
C2653    #2746    0      9.503470e-15
C2654    #2747    0      9.503470e-15
C2655    #2731    0      9.745988e-15
C2656    #2748    0      9.503470e-15
C2657    #2749    0      9.503470e-15
C2658    #2733    0      9.745988e-15
C2659    #2750    0      9.503470e-15
C2660    #2752    0      8.884447e-15
C2661    #2735    0      9.745988e-15
C2662    #2698    0      7.362503e-14
C2663    #2682    0      7.464903e-14
C2664    #2683    0      7.593803e-14
C2665    #2684    0      7.817605e-14
C2666    #2685    0      7.655303e-14
C2667    #2686    0      7.817605e-14
C2668    #2687    0      7.655303e-14
C2669    #2688    0      7.817605e-14
C2670    #2689    0      7.655303e-14
C2671    #2690    0      7.817605e-14
C2672    #2691    0      7.655303e-14
C2673    #2692    0      7.817605e-14
C2674    #2693    0      7.655303e-14
C2675    #2694    0      7.817605e-14
C2676    #2695    0      7.655303e-14
C2677    #2696    0      7.902905e-14
C2678    #2697    0      7.689703e-14
C2679    #2754    0      7.785823e-15
C2680    #2755    0      7.807823e-15
C2681    #2756    0      7.807823e-15
C2682    #2757    0      7.807823e-15
C2683    #2758    0      7.807823e-15
C2684    #2759    0      7.807823e-15
C2685    #2760    0      7.807823e-15
C2686    #2761    0      7.807823e-15
C2687    #2762    0      7.807823e-15
C2688    #2763    0      7.807823e-15
C2689    #2764    0      7.807823e-15
C2690    #2765    0      7.807823e-15
C2691    #2766    0      7.807823e-15
C2692    #2767    0      7.807823e-15
C2693    #2768    0      7.807823e-15
C2694    #2769    0      7.807823e-15
C2695    #2770    0      7.807823e-15
C2696    #2771    0      8.294095e-15
C2697    #2772    0      8.316096e-15
C2698    #2773    0      8.316096e-15
C2699    #2774    0      8.316096e-15
C2700    #2775    0      8.316096e-15
C2701    #2776    0      8.316096e-15
C2702    #2777    0      8.316096e-15
C2703    #2778    0      8.316096e-15
C2704    #2779    0      8.316096e-15
C2705    #2780    0      8.316096e-15
C2706    #2781    0      8.316096e-15
C2707    #2782    0      8.316096e-15
C2708    #2783    0      8.316096e-15
C2709    #2784    0      8.316096e-15
C2710    #2785    0      8.316096e-15
C2711    #2786    0      8.316096e-15
C2712    #2787    0      8.316096e-15
C2713    #2753    0      4.792581e-13
C2714    #2710    0      3.475627e-14
C2715    #2663    0      6.122453e-14
C2716    #2702    0      3.414927e-14
C2717    #2649    0      6.932994e-14
C2718    #2711    0      3.404927e-14
C2719    #2650    0      6.666279e-14
C2720    #2703    0      3.394727e-14
C2721    #2651    0      6.585579e-14
C2722    #2712    0      3.404927e-14
C2723    #2652    0      6.658279e-14
C2724    #2704    0      3.394727e-14
C2725    #2653    0      6.585579e-14
C2726    #2713    0      3.404927e-14
C2727    #2654    0      6.658279e-14
C2728    #2705    0      3.394727e-14
C2729    #2655    0      6.585579e-14
C2730    #2714    0      3.404927e-14
C2731    #2656    0      6.658279e-14
C2732    #2706    0      3.394727e-14
C2733    #2657    0      6.585579e-14
C2734    #2715    0      3.404927e-14
C2735    #2658    0      6.658279e-14
C2736    #2707    0      3.394727e-14
C2737    #2659    0      6.585579e-14
C2738    #2716    0      3.404927e-14
C2739    #2660    0      6.658279e-14
C2740    #2708    0      3.394727e-14
C2741    #2661    0      6.585579e-14
C2742    #2717    0      3.404927e-14
C2743    #2662    0      6.658279e-14
C2744    #2709    0      3.463027e-14
C2745    #2647    0      6.751379e-14
C2746    #2718    0      3.471027e-14
C2747    #2646    0      7.387979e-14
C2748    #2824    0      2.752763e-14
C2749    #2825    0      1.470808e-14
C2750    #2823    0      1.863045e-14
C2751    #2789    0      1.869816e-14
C2752    #2611    0      1.023898e-13
C2753    #2827    0      1.042716e-14
C2754    #2829    0      1.222359e-14
C2755    #2681    0      2.168122e-13
C2756    #2831    0      1.232059e-14
C2757    #2791    0      4.493020e-14
C2758    #2849    0      1.120425e-14
C2759    #2793    0      5.261559e-14
C2760    #2794    0      5.231759e-14
C2761    #2795    0      5.261559e-14
C2762    #2796    0      5.231759e-14
C2763    #2797    0      5.261559e-14
C2764    #2798    0      5.231759e-14
C2765    #2799    0      5.261559e-14
C2766    #2800    0      5.231759e-14
C2767    #2801    0      5.261559e-14
C2768    #2802    0      5.231759e-14
C2769    #2803    0      5.261559e-14
C2770    #2804    0      5.231759e-14
C2771    #2805    0      5.261559e-14
C2772    #2806    0      5.231759e-14
C2773    #2807    0      5.261559e-14
C2774    #2808    0      4.925286e-14
C2775    #2809    0      4.954986e-14
C2776    #2810    0      4.925286e-14
C2777    #2811    0      4.954986e-14
C2778    #2812    0      4.925286e-14
C2779    #2813    0      4.954986e-14
C2780    #2814    0      4.925286e-14
C2781    #2815    0      4.954986e-14
C2782    #2816    0      4.925286e-14
C2783    #2817    0      4.954986e-14
C2784    #2818    0      4.925286e-14
C2785    #2819    0      4.954986e-14
C2786    #2820    0      4.925286e-14
C2787    #2821    0      4.954986e-14
C2788    #2822    0      4.925286e-14
C2789    #2851    0      1.455661e-14
C2790    #2848    0      4.465194e-14
C2791    X3       0      2.401746e-13
C2792    #2832    0      7.375704e-14
C2793    #2868    0      1.455608e-14
C2794    #2790    0      8.458875e-14
C2795    #2850    0      1.922745e-14
C2796    #2828    0      4.953397e-14
C2797    #2870    0      1.152330e-14
C2798    #2871    0      1.138806e-14
C2799    #2872    0      1.187606e-14
C2800    #2873    0      1.138806e-14
C2801    #2874    0      1.187606e-14
C2802    #2875    0      1.138806e-14
C2803    #2876    0      1.187606e-14
C2804    #2877    0      1.138806e-14
C2805    #2878    0      1.187606e-14
C2806    #2879    0      1.138806e-14
C2807    #2880    0      1.187606e-14
C2808    #2881    0      1.138806e-14
C2809    #2882    0      1.187606e-14
C2810    #2883    0      1.138806e-14
C2811    #2884    0      1.187606e-14
C2812    #2886    0      1.257959e-14
C2813    #2887    0      1.204059e-14
C2814    #2888    0      1.257959e-14
C2815    #2889    0      1.204059e-14
C2816    #2890    0      1.257959e-14
C2817    #2891    0      1.204059e-14
C2818    #2892    0      1.257959e-14
C2819    #2893    0      1.204059e-14
C2820    #2894    0      1.257959e-14
C2821    #2895    0      1.204059e-14
C2822    #2896    0      1.257959e-14
C2823    #2897    0      1.204059e-14
C2824    #2898    0      1.257959e-14
C2825    #2899    0      1.204059e-14
C2826    #2885    0      1.213392e-14
C2827    #2901    0      2.767863e-14
C2828    #2612    0      2.409255e-13
C2829    #2406    0      1.054867e-13
C2830    #2869    0      1.869816e-14
C2831    X2       0      1.581687e-13
C2832    #2937    0      3.773348e-15
C2833    #2938    0      1.063814e-14
C2834    #2935    0      7.188703e-14
C2835    #2905    0      2.105623e-14
C2836    #2907    0      2.109423e-14
C2837    #2909    0      2.109423e-14
C2838    #2911    0      2.109423e-14
C2839    #2913    0      2.109423e-14
C2840    #2915    0      2.109423e-14
C2841    #2917    0      2.109423e-14
C2842    #2919    0      2.109423e-14
C2843    #2920    0      2.007503e-14
C2844    #2921    0      2.007503e-14
C2845    #2922    0      2.007503e-14
C2846    #2923    0      2.007503e-14
C2847    #2924    0      2.007503e-14
C2848    #2925    0      2.007503e-14
C2849    #2926    0      2.007503e-14
C2850    #2927    0      2.007503e-14
C2851    #2928    0      2.007503e-14
C2852    #2929    0      2.007503e-14
C2853    #2930    0      2.007503e-14
C2854    #2931    0      2.007503e-14
C2855    #2932    0      2.007503e-14
C2856    #2788    0      1.075261e-13
C2857    #2933    0      2.007503e-14
C2858    #2934    0      2.007503e-14
C2859    #2906    0      2.113223e-14
C2860    #2908    0      2.113223e-14
C2861    #2910    0      2.113223e-14
C2862    #2912    0      2.113223e-14
C2863    #2914    0      2.113223e-14
C2864    #2916    0      2.113223e-14
C2865    #2918    0      2.113223e-14
C2866    #2902    0      2.917067e-14
C2867    #2904    0      2.471003e-14
C2868    #2903    0      2.694664e-14
C2869    #2852    0      9.687889e-14
C2870    #2853    0      9.687489e-14
C2871    #2854    0      9.669888e-14
C2872    #2855    0      9.672788e-14
C2873    #2856    0      9.669888e-14
C2874    #2857    0      9.672788e-14
C2875    #2858    0      9.669888e-14
C2876    #2859    0      9.672788e-14
C2877    #2860    0      9.669888e-14
C2878    #2861    0      9.672788e-14
C2879    #2862    0      9.669888e-14
C2880    #2863    0      9.672788e-14
C2881    #2864    0      9.669888e-14
C2882    #2865    0      9.672788e-14
C2883    #2700    0      8.572569e-14
C2884    Z18      0      3.714827e-14
C2885    #2955    0      1.056918e-14
C2886    #2956    0      1.048203e-14
C2887    #2957    0      1.048203e-14
C2888    #2958    0      1.048203e-14
C2889    #2959    0      1.048203e-14
C2890    #2960    0      1.048203e-14
C2891    #2961    0      1.048203e-14
C2892    #2962    0      1.048203e-14
C2893    #2963    0      1.048203e-14
C2894    #2964    0      1.048203e-14
C2895    #2965    0      1.048203e-14
C2896    #2966    0      1.048203e-14
C2897    #2967    0      1.048203e-14
C2898    #2968    0      1.048203e-14
C2899    #2969    0      1.048203e-14
C2900    #2936    0      7.901629e-14
C2901    #2985    0      1.132230e-14
C2902    #2699    0      1.673100e-13
C2903    #2970    0      9.993449e-15
C2904    #2597    0      1.840860e-13
C2905    #2971    0      9.993449e-15
C2906    #2605    0      1.872908e-13
C2907    #2972    0      9.993449e-15
C2908    #2598    0      1.844157e-13
C2909    #2973    0      9.993449e-15
C2910    #2606    0      1.872238e-13
C2911    #2974    0      9.993449e-15
C2912    #2599    0      1.844157e-13
C2913    #2975    0      9.993449e-15
C2914    #2607    0      1.872238e-13
C2915    #2976    0      9.993449e-15
C2916    #2600    0      1.844157e-13
C2917    #2977    0      9.993449e-15
C2918    #2608    0      1.872238e-13
C2919    #2978    0      9.993449e-15
C2920    #2601    0      1.844157e-13
C2921    #2979    0      9.993449e-15
C2922    #2609    0      1.872238e-13
C2923    #2980    0      9.993449e-15
C2924    #2602    0      1.844157e-13
C2925    #2981    0      9.993449e-15
C2926    #2610    0      1.872238e-13
C2927    #2982    0      9.993449e-15
C2928    #2603    0      1.844157e-13
C2929    #2983    0      9.993449e-15
C2930    #2701    0      7.070788e-13
C2931    #2984    0      1.015745e-14
C2932    #2830    0      1.378873e-13
C2933    #2986    0      1.227659e-14
C2934    #3003    0      1.132230e-14
C2935    #2988    0      1.153895e-14
C2936    #2990    0      1.153895e-14
C2937    #2992    0      1.153895e-14
C2938    #2994    0      1.153895e-14
C2939    #2996    0      1.153895e-14
C2940    #2998    0      1.153895e-14
C2941    #3000    0      1.153895e-14
C2942    #3004    0      1.213392e-14
C2943    #3006    0      1.213392e-14
C2944    #3008    0      1.213392e-14
C2945    #3010    0      1.213392e-14
C2946    #3012    0      1.213392e-14
C2947    #3014    0      1.213392e-14
C2948    #3016    0      1.213392e-14
C2949    #2604    0      1.628715e-13
C2950    #3019    0      1.289259e-14
C2951    #3005    0      1.306726e-14
C2952    #3007    0      1.306726e-14
C2953    #3009    0      1.306726e-14
C2954    #3011    0      1.306726e-14
C2955    #3013    0      1.306726e-14
C2956    #3015    0      1.306726e-14
C2957    #3017    0      1.306726e-14
C2958    #2989    0      1.395308e-14
C2959    #2991    0      1.395308e-14
C2960    #2993    0      1.395308e-14
C2961    #2995    0      1.395308e-14
C2962    #2997    0      1.395308e-14
C2963    #2999    0      1.395308e-14
C2964    #3001    0      1.395308e-14
C2965    #3018    0      1.428060e-14
C2966    #2987    0      1.606544e-14
C2967    #2867    0      4.944033e-14
C2968    #3021    0      4.250638e-15
C2969    #2954    0      4.351619e-14
C2970    Z17      0      1.684745e-14
C2971    #3002    0      1.209989e-14
C2972    #2947    0      6.952578e-14
C2973    #2940    0      6.808735e-14
C2974    #2948    0      6.903778e-14
C2975    #2941    0      6.808735e-14
C2976    #2949    0      6.903778e-14
C2977    #2942    0      6.808735e-14
C2978    #2950    0      6.903778e-14
C2979    #2943    0      6.808735e-14
C2980    #2951    0      6.903778e-14
C2981    #2944    0      6.808735e-14
C2982    #2952    0      6.903778e-14
C2983    #2945    0      6.808735e-14
C2984    #2953    0      6.903778e-14
C2985    #2946    0      6.808735e-14
C2986    #2939    0      6.505478e-14
C2987    #3041    0      1.143919e-14
C2988    #3056    0      9.595039e-15
C2989    #3057    0      1.106019e-14
C2990    #3058    0      1.106019e-14
C2991    #3059    0      1.106019e-14
C2992    #3060    0      1.106019e-14
C2993    #3061    0      1.106019e-14
C2994    #3062    0      1.106019e-14
C2995    #3063    0      1.106019e-14
C2996    #3064    0      1.106019e-14
C2997    #3065    0      1.106019e-14
C2998    #3066    0      1.106019e-14
C2999    #3067    0      1.106019e-14
C3000    #3068    0      1.106019e-14
C3001    #3069    0      1.106019e-14
C3002    #3070    0      1.106019e-14
C3003    #37      0      4.854315e-13
C3004    #52      0      7.068942e-13
C3005    #38      0      5.059402e-13
C3006    #39      0      5.027712e-13
C3007    #40      0      5.049182e-13
C3008    #41      0      5.027712e-13
C3009    #42      0      5.049182e-13
C3010    #43      0      5.027712e-13
C3011    #44      0      5.049182e-13
C3012    #45      0      5.027712e-13
C3013    #46      0      5.049182e-13
C3014    #47      0      5.027712e-13
C3015    #48      0      5.049182e-13
C3016    #49      0      5.027712e-13
C3017    #50      0      5.049182e-13
C3018    #51      0      5.110802e-13
C3019    #3089    0      8.235861e-15
C3020    #3090    0      7.845823e-15
C3021    #3091    0      7.845823e-15
C3022    #3092    0      7.845823e-15
C3023    #3093    0      7.845823e-15
C3024    #3094    0      7.845823e-15
C3025    #3095    0      7.845823e-15
C3026    #3096    0      7.845823e-15
C3027    #3097    0      7.845823e-15
C3028    #3098    0      7.845823e-15
C3029    #3099    0      7.845823e-15
C3030    #3100    0      7.845823e-15
C3031    #3101    0      7.845823e-15
C3032    #3102    0      7.845823e-15
C3033    #3103    0      7.845823e-15
C3034    #3104    0      7.845823e-15
C3035    #3105    0      7.845823e-15
C3036    #3037    0      5.502429e-13
C3037    #3042    0      2.105203e-14
C3038    #3043    0      2.105203e-14
C3039    #3044    0      2.105203e-14
C3040    #3045    0      2.105203e-14
C3041    #3046    0      2.105203e-14
C3042    #3047    0      2.105203e-14
C3043    #3048    0      2.105203e-14
C3044    #3049    0      2.105203e-14
C3045    #3050    0      2.105203e-14
C3046    #3051    0      2.105203e-14
C3047    #3052    0      2.105203e-14
C3048    #3053    0      2.105203e-14
C3049    #3054    0      2.105203e-14
C3050    #3055    0      2.105203e-14
C3051    #3039    0      2.381583e-14
C3052    #3040    0      2.405351e-14
C3053    #2833    0      2.044358e-13
C3054    #2834    0      2.052028e-13
C3055    #2835    0      2.037888e-13
C3056    #2836    0      2.042988e-13
C3057    #2837    0      2.037888e-13
C3058    #2838    0      2.042988e-13
C3059    #2839    0      2.037888e-13
C3060    #2840    0      2.042988e-13
C3061    #2841    0      2.037888e-13
C3062    #2842    0      2.042988e-13
C3063    #2843    0      2.037888e-13
C3064    #2844    0      2.042988e-13
C3065    #2845    0      2.037888e-13
C3066    #2846    0      2.046338e-13
C3067    #2847    0      2.051018e-13
C3068    #3073    0      5.728975e-13
C3069    #3176    0      8.728107e-15
C3070    #3144    0      9.504963e-15
C3071    #3147    0      9.504963e-15
C3072    #3149    0      9.504963e-15
C3073    #3151    0      9.504963e-15
C3074    #3153    0      9.504963e-15
C3075    #3155    0      9.504963e-15
C3076    #3157    0      9.504963e-15
C3077    #3159    0      9.504963e-15
C3078    #3145    0      9.745988e-15
C3079    #3161    0      9.503470e-15
C3080    #3162    0      9.503470e-15
C3081    #3146    0      9.745988e-15
C3082    #3163    0      9.503470e-15
C3083    #3164    0      9.503470e-15
C3084    #3148    0      9.745988e-15
C3085    #3165    0      9.503470e-15
C3086    #3166    0      9.503470e-15
C3087    #3150    0      9.745988e-15
C3088    #3167    0      9.503470e-15
C3089    #3168    0      9.503470e-15
C3090    #3152    0      9.745988e-15
C3091    #3169    0      9.503470e-15
C3092    #3170    0      9.503470e-15
C3093    #3154    0      9.745988e-15
C3094    #3171    0      9.503470e-15
C3095    #3172    0      9.503470e-15
C3096    #3156    0      9.745988e-15
C3097    #3173    0      9.503470e-15
C3098    #3174    0      9.503470e-15
C3099    #3158    0      9.745988e-15
C3100    #3175    0      9.503470e-15
C3101    #3177    0      8.884447e-15
C3102    #3160    0      9.745988e-15
C3103    #3123    0      7.362503e-14
C3104    #3107    0      7.464903e-14
C3105    #3108    0      7.593803e-14
C3106    #3109    0      7.817605e-14
C3107    #3110    0      7.655303e-14
C3108    #3111    0      7.817605e-14
C3109    #3112    0      7.655303e-14
C3110    #3113    0      7.817605e-14
C3111    #3114    0      7.655303e-14
C3112    #3115    0      7.817605e-14
C3113    #3116    0      7.655303e-14
C3114    #3117    0      7.817605e-14
C3115    #3118    0      7.655303e-14
C3116    #3119    0      7.817605e-14
C3117    #3120    0      7.655303e-14
C3118    #3121    0      8.012306e-14
C3119    #3122    0      7.740103e-14
C3120    #3179    0      7.785823e-15
C3121    #3180    0      7.807823e-15
C3122    #3181    0      7.807823e-15
C3123    #3182    0      7.807823e-15
C3124    #3183    0      7.807823e-15
C3125    #3184    0      7.807823e-15
C3126    #3185    0      7.807823e-15
C3127    #3186    0      7.807823e-15
C3128    #3187    0      7.807823e-15
C3129    #3188    0      7.807823e-15
C3130    #3189    0      7.807823e-15
C3131    #3190    0      7.807823e-15
C3132    #3191    0      7.807823e-15
C3133    #3192    0      7.807823e-15
C3134    #3193    0      7.807823e-15
C3135    #3194    0      7.807823e-15
C3136    #3195    0      7.807823e-15
C3137    #3196    0      8.294095e-15
C3138    #3197    0      8.316096e-15
C3139    #3198    0      8.316096e-15
C3140    #3199    0      8.316096e-15
C3141    #3200    0      8.316096e-15
C3142    #3201    0      8.316096e-15
C3143    #3202    0      8.316096e-15
C3144    #3203    0      8.316096e-15
C3145    #3204    0      8.316096e-15
C3146    #3205    0      8.316096e-15
C3147    #3206    0      8.316096e-15
C3148    #3207    0      8.316096e-15
C3149    #3208    0      8.316096e-15
C3150    #3209    0      8.316096e-15
C3151    #3210    0      8.316096e-15
C3152    #3211    0      8.316096e-15
C3153    #3212    0      8.316096e-15
C3154    #3178    0      4.797651e-13
C3155    #3134    0      3.475627e-14
C3156    #3088    0      6.122453e-14
C3157    #3127    0      3.414927e-14
C3158    #3074    0      6.932994e-14
C3159    #3136    0      3.404927e-14
C3160    #3075    0      6.666279e-14
C3161    #3128    0      3.394727e-14
C3162    #3076    0      6.585579e-14
C3163    #3137    0      3.404927e-14
C3164    #3077    0      6.658279e-14
C3165    #3129    0      3.394727e-14
C3166    #3078    0      6.585579e-14
C3167    #3138    0      3.404927e-14
C3168    #3079    0      6.658279e-14
C3169    #3130    0      3.394727e-14
C3170    #3080    0      6.585579e-14
C3171    #3139    0      3.404927e-14
C3172    #3081    0      6.658279e-14
C3173    #3131    0      3.394727e-14
C3174    #3082    0      6.585579e-14
C3175    #3140    0      3.404927e-14
C3176    #3083    0      6.658279e-14
C3177    #3132    0      3.394727e-14
C3178    #3084    0      6.585579e-14
C3179    #3141    0      3.404927e-14
C3180    #3085    0      6.658279e-14
C3181    #3133    0      3.394727e-14
C3182    #3086    0      6.585579e-14
C3183    #3142    0      3.404927e-14
C3184    #3087    0      6.658279e-14
C3185    #3135    0      3.483027e-14
C3186    #3071    0      6.842947e-14
C3187    #3143    0      3.500727e-14
C3188    #3072    0      7.420579e-14
C3189    #3246    0      9.972064e-15
C3190    X1       0      1.991045e-13
C3191    #3106    0      1.922476e-13
C3192    #3263    0      1.002650e-14
C3193    #3264    0      1.133746e-14
C3194    #3266    0      1.048103e-14
C3195    #3267    0      1.048103e-14
C3196    #3268    0      1.048103e-14
C3197    #3269    0      1.048103e-14
C3198    #3270    0      1.048103e-14
C3199    #3271    0      1.048103e-14
C3200    #3272    0      1.048103e-14
C3201    #3280    0      1.076355e-14
C3202    #3273    0      1.183268e-14
C3203    #3274    0      1.183268e-14
C3204    #3275    0      1.183268e-14
C3205    #3276    0      1.183268e-14
C3206    #3277    0      1.183268e-14
C3207    #3278    0      1.183268e-14
C3208    #3279    0      1.183268e-14
C3209    #3038    0      2.250631e-13
C3210    X0       0      4.119215e-14
C3211    #3254    0      3.086815e-14
C3212    #3255    0      3.086815e-14
C3213    #3247    0      3.038501e-14
C3214    #3256    0      3.086815e-14
C3215    #3248    0      3.038501e-14
C3216    #3257    0      3.086815e-14
C3217    #3249    0      3.038501e-14
C3218    #3258    0      3.086815e-14
C3219    #3250    0      3.038501e-14
C3220    #3259    0      3.086815e-14
C3221    #3251    0      3.038501e-14
C3222    #3260    0      3.086815e-14
C3223    #3252    0      3.038501e-14
C3224    #3261    0      3.086815e-14
C3225    #3253    0      3.038501e-14
C3226    #3262    0      3.086815e-14
C3227    #3265    0      3.038501e-14
C3228    #3125    0      7.044183e-14
C3229    #3029    0      1.301186e-13
C3230    #3124    0      1.084349e-13
C3231    #3030    0      1.291827e-13
C3232    #3031    0      1.291157e-13
C3233    #3032    0      1.291157e-13
C3234    #3033    0      1.291157e-13
C3235    #3034    0      1.291157e-13
C3236    #3035    0      1.291157e-13
C3237    #3036    0      1.302857e-13
C3238    #3022    0      1.329252e-13
C3239    #3023    0      1.332560e-13
C3240    #3024    0      1.332560e-13
C3241    #3025    0      1.332560e-13
C3242    #3026    0      1.332560e-13
C3243    #3027    0      1.332560e-13
C3244    #3028    0      1.332560e-13
C3245    #3126    0      6.555990e-13
C3246    #3229    0      3.135301e-14
C3247    #3221    0      8.258303e-14
C3248    #3222    0      8.258303e-14
C3249    #3223    0      8.258303e-14
C3250    #3224    0      8.258303e-14
C3251    #3225    0      8.258303e-14
C3252    #3226    0      8.258303e-14
C3253    #3227    0      8.258303e-14
C3254    #3228    0      8.314224e-14
C3255    #3231    0      2.979804e-14
C3256    #3232    0      2.979804e-14
C3257    #3233    0      2.979804e-14
C3258    #3234    0      2.979804e-14
C3259    #3235    0      2.979804e-14
C3260    #3236    0      2.979804e-14
C3261    #3237    0      2.979804e-14
C3262    #3213    0      3.315275e-14
C3263    #3282    0      2.056698e-14
C3264    #3290    0      1.998949e-14
C3265    #3283    0      2.006008e-14
C3266    #3284    0      2.006008e-14
C3267    #3285    0      2.006008e-14
C3268    #3286    0      2.006008e-14
C3269    #3287    0      2.006008e-14
C3270    #3288    0      2.006008e-14
C3271    #3289    0      2.006008e-14
C3272    #3298    0      1.969439e-14
C3273    #3291    0      2.065394e-14
C3274    #3292    0      2.065394e-14
C3275    #3293    0      2.065394e-14
C3276    #3294    0      2.065394e-14
C3277    #3295    0      2.065394e-14
C3278    #3296    0      2.065394e-14
C3279    #3297    0      2.065394e-14
C3280    #3316    0      4.430060e-15
C3281    #3318    0      4.077603e-15
C3282    #3319    0      3.983603e-15
C3283    #3320    0      4.077603e-15
C3284    #3321    0      3.983603e-15
C3285    #3322    0      4.077603e-15
C3286    #3323    0      3.983603e-15
C3287    #3324    0      4.077603e-15
C3288    #3325    0      3.983603e-15
C3289    #3326    0      4.077603e-15
C3290    #3327    0      3.983603e-15
C3291    #3328    0      4.077603e-15
C3292    #3329    0      3.983603e-15
C3293    #3330    0      4.077603e-15
C3294    #3331    0      3.983603e-15
C3295    #3332    0      4.077603e-15
C3296    #3317    0      4.143624e-15
C3297    #2866    0      1.225159e-13
C3298    Z16      0      1.933774e-14
C3299    #3230    0      8.970471e-14
C3300    Z0       0      1.891452e-14
C3301    #3214    0      8.977148e-14
C3302    Z2       0      1.891452e-14
C3303    #3215    0      8.977148e-14
C3304    Z4       0      1.891452e-14
C3305    #3216    0      8.977148e-14
C3306    Z6       0      1.891452e-14
C3307    #3217    0      8.977148e-14
C3308    Z8       0      1.891452e-14
C3309    #3218    0      8.977148e-14
C3310    Z10      0      1.891452e-14
C3311    #3219    0      8.977148e-14
C3312    Z12      0      1.891452e-14
C3313    #3220    0      9.016448e-14
C3314    Z14      0      1.891452e-14
C3315    #3238    0      3.680201e-14
C3316    Z1       0      2.008150e-14
C3317    #3239    0      3.680201e-14
C3318    Z3       0      2.008150e-14
C3319    #3240    0      3.680201e-14
C3320    Z5       0      2.008150e-14
C3321    #3241    0      3.680201e-14
C3322    Z7       0      2.008150e-14
C3323    #3242    0      3.680201e-14
C3324    Z9       0      2.008150e-14
C3325    #3243    0      3.680201e-14
C3326    Z11      0      2.008150e-14
C3327    #3244    0      3.680201e-14
C3328    Z13      0      2.008150e-14
C3329    #3245    0      3.722001e-14
C3330    Z15      0      2.028850e-14
*
VDD  1   0   PULSE (0 5.0 0N 1N 1N 600N 1000N)
*
V1   x1   0   DC  0
V2   x2   0   DC  0
V3   x3   0   DC  0
V4   x4   0   DC  0
V5   x5   0   DC  0
V6   x6   0   PULSE (0 5.0 0N 1N 1N 600N 1000N)
V7   x7   0   PULSE (0 5.0 0N 1N 1N 600N 1000N)
V8   x8   0   DC  0
V9   x9   0   DC  0
V10  x10  0   PULSE (0 5.0 0N 1N 1N 600N 1000N)
V11  x11  0   DC  0
V12  x12  0   PULSE (0 5.0 0N 1N 1N 600N 1000N)
V13  x13  0   PULSE (0 5.0 0N 1N 1N 600N 1000N)
V14  x14  0   DC  0
V15  x15  0   PULSE (0 5.0 0N 1N 1N 600N 1000N)

V20  y0  0   PULSE (0 5.0 0N 1N 1N 600N 1000N)
V21  y1  0   DC  0
V22  y2  0   DC  0
V23  y3  0   PULSE (0 5.0 0N 1N 1N 600N 1000N)
V24  y4  0   DC  0
V25  y5  0   DC  0
V26  y6  0   PULSE (0 5.0 0N 1N 1N 600N 1000N)
V27  y7  0   DC  0.0
V28  y8  0   PULSE (0 5.0 0N 1N 1N 600N 1000N)
V29  y9  0   DC  0
V30  y10 0   PULSE (0 5.0 0N 1N 1N 600N 1000N)
V31  y11 0   DC  0
V32  y12 0   PULSE (0 5.0 0N 1N 1N 600N 1000N)
V33  y13 0   PULSE (0 5.0 0N 1N 1N 600N 1000N)
V34  y14 0   DC  0
V35  y15 0   PULSE (0 5.0 0N 1N 1N 600N 1000N)

V0   x0 0   PULSE (0 5.0 49.5N 0.5N 0.5N 49.5N 100N)
*
.TRAN 1N 600N
.PRINT tran z0 z1 z2 z3 z4 z5 z6 z7 z8 z9 z10 z10 z11 z12 z13 z14 z15 z16 z17
+z18 z19 z20 z21 z22  z23 z24 z25  z26 z27 z28 z29 z30 z31
*
.MODEL MN1 NMOS VTO=0.8 KP=48U GAMMA=0.30 PHI=0.55 LAMBDA=0.00 CGSO=0 CGDO=0
+CJ=0 CJSW=0 TOX=18000N LD=0.0U
.MODEL MP1 PMOS VTO=-0.8 KP=21U GAMMA=0.45 PHI=0.61 LAMBDA=0.00 CGSO=0 CGDO=0
+CJ=0 CJSW=0 TOX=18000N LD=0.0U
.options reltol=0.1 gmin=1e-8
.END
*
